/*
 * nano_j2me - tests/test_m4v.c
 *
 * MPEG-4 Visual framing, checked against the decoder configurations of the two
 * real movies in the corpus (1942.3gp, doom.3gp) rather than a header we wrote
 * ourselves: a synthetic header only proves the parser matches the writer.
 */
#include "nj2me/nj.h"
#include "nj2me/nj_m4v.h"
#include "nj2me/nj_avcodec.h"
#include "m4v_clip.h"
#include "nj_vlc_intra.h"
#include "nj2me/nj_m4v_escape.h"
#include "nj2me/nj_m4v_tables.h"

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

static int checks;
static int fails;

static void ok(int cond, const char *what)
{
    checks++;
    if (!cond) {
        fails++;
        fprintf(stderr, "FAIL: %s\n", what);
    }
}

/* FNV-1a over a plane, used to pin whole reference frames compactly. */
static nj_u4 fnv1a(const nj_u1 *p, nj_u4 n)
{
    nj_u4 h = 2166136261u;

    while (n-- > 0u) {
        h ^= *p++;
        h *= 16777619u;
    }
    return h;
}

/* esds DecoderSpecificInfo of vault/1942: 176x144, 25 fps, time_res 1000. */
static const nj_u1 cfg_1942[] = {
    0x00, 0x00, 0x01, 0xb0, 0xf0, 0x00, 0x00, 0x01, 0xb5, 0x0e, 0xe0, 0x40,
    0xc0, 0xcf, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x20, 0x00, 0x84,
    0x40, 0xfa, 0x28, 0x2c, 0x20, 0x90, 0xa3, 0x1f
};

/* esds DecoderSpecificInfo of vid/doom.3gp: 320x240, 15 fps. */
static const nj_u1 cfg_doom[] = {
    0x00, 0x00, 0x01, 0xb0, 0x00, 0x00, 0x00, 0x01, 0xb5, 0x89, 0x13, 0x00,
    0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x20, 0x00, 0xc4, 0x8d, 0x88, 0x00,
    0x7d, 0x0a, 0x04, 0x1e, 0x14, 0x63, 0x00, 0x00, 0x01, 0xb2, 0x61, 0x76,
    0x63, 0x32, 0x2e, 0x30, 0x2e, 0x31, 0x31, 0x2e, 0x31, 0x31, 0x31, 0x30
};

/*
 * The four video samples of 1942.3gp that the round-trip test decodes in
 * sequence: I, P, I, P.  They are the container's own bytes (each begins
 * with the VOP start code), so the test needs no file access and no
 * container parser; the VOL comes from cfg_1942 above.  The reference
 * hashes and pixels below were produced by FFmpeg on the same file; the
 * decoder must reproduce them exactly, which fails on any regression in
 * the motion compensation, motion-vector prediction, rounding type or
 * IDCT.  Frame 1 is training material for the first P-VOP, frame 3 has
 * 16x16 inter macroblocks with real vectors, 4MV ones and intra ones.
 */
static const nj_u1 m4v_sample_0[286] = {
    0x00, 0x00, 0x01, 0xb6, 0x10, 0x03, 0x09, 0x8c, 0x21, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb,
    0x6f, 0xc4, 0x63, 0x6d, 0xf8, 0x8c, 0x6d, 0xbf, 0x8d, 0xb6, 0xfc, 0x46, 0x36, 0xdd, 0xb1,
    0xb6, 0xdf, 0x88, 0xc6, 0xdb, 0xf8, 0xdb, 0x6f, 0xc4, 0x63, 0x6d, 0xfc, 0x6d, 0xb7, 0xe2,
    0x31, 0xb6, 0xfe, 0x36, 0xdb, 0xf1, 0x18, 0xdb, 0x7f, 0x1b, 0x6d, 0xf8, 0x8c, 0x6d, 0xbf,
    0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36,
    0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f,
    0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d,
    0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb,
    0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3,
    0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6,
    0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8,
    0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d,
    0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe,
    0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb,
    0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf,
    0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36,
    0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f,
    0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d,
    0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb,
    0xf7
};
static const nj_u1 m4v_sample_1[426] = {
    0x00, 0x00, 0x01, 0xb6, 0x50, 0xa3, 0x82, 0x1f, 0xfe, 0xb7, 0x01, 0x64, 0xa6, 0xa8, 0x3a,
    0x07, 0xce, 0x80, 0x1c, 0x7c, 0x1d, 0x03, 0xe7, 0x40, 0x12, 0x69, 0xea, 0x81, 0xf8, 0xa0,
    0x07, 0x54, 0x0f, 0xc5, 0x00, 0x39, 0xa7, 0xaa, 0x06, 0x05, 0x92, 0xa0, 0x60, 0x59, 0x1a,
    0x7f, 0x81, 0x81, 0x65, 0xe0, 0x60, 0x59, 0x1a, 0x3f, 0x81, 0x81, 0x65, 0xe0, 0x60, 0x59,
    0x1a, 0x3a, 0xa0, 0x7e, 0x28, 0x01, 0xd5, 0x03, 0x02, 0xc8, 0xd1, 0xd5, 0x03, 0xf1, 0x40,
    0x0f, 0xe0, 0x60, 0x59, 0x29, 0xc0, 0x59, 0x40, 0x59, 0x66, 0x2f, 0x54, 0x0f, 0xc5, 0x00,
    0x3c, 0x05, 0x91, 0x70, 0x3f, 0x14, 0x00, 0xe6, 0x7f, 0xe0, 0x60, 0x59, 0x2a, 0x06, 0x05,
    0x92, 0xa0, 0x60, 0x59, 0x2a, 0x07, 0xe2, 0x80, 0x1c, 0xcf, 0xd5, 0x03, 0x02, 0xc9, 0x50,
    0x30, 0x2c, 0x95, 0x03, 0x02, 0xc9, 0x50, 0x30, 0x2c, 0x8c, 0xff, 0xc0, 0xb2, 0xf0, 0x30,
    0x2c, 0xbc, 0x0b, 0x2f, 0x02, 0xc8, 0x23, 0xc2, 0xa8, 0x3f, 0x14, 0x00, 0xac, 0x1f, 0x8a,
    0x00, 0x5e, 0x0f, 0xc5, 0x00, 0x2f, 0x07, 0xe2, 0x80, 0x16, 0x61, 0x1f, 0x20, 0xe0, 0x91,
    0x83, 0x82, 0x46, 0x0f, 0xc5, 0x00, 0x2c, 0x83, 0x82, 0x4b, 0x99, 0xfc, 0x05, 0x94, 0x05,
    0x97, 0x81, 0x65, 0xe0, 0x59, 0x18, 0xce, 0x02, 0xcb, 0xc0, 0xb2, 0xf0, 0x2c, 0x8c, 0x6f,
    0x01, 0x64, 0xa8, 0x18, 0x16, 0x5e, 0x05, 0x91, 0xc3, 0xc0, 0x59, 0x4e, 0x9f, 0xc0, 0xb2,
    0x39, 0x7f, 0x03, 0x02, 0xca, 0x02, 0xc8, 0xe5, 0xd5, 0x60, 0x78, 0x0c, 0x2c, 0x98, 0x09,
    0xc6, 0x47, 0x77, 0xac, 0x4c, 0x58, 0x36, 0x7b, 0x81, 0x8f, 0xc4, 0x8c, 0x4c, 0x58, 0x0f,
    0x9d, 0x00, 0x48, 0x3c, 0x04, 0x03, 0x77, 0xc1, 0xf0, 0x3e, 0x74, 0x01, 0xb0, 0x16, 0x45,
    0xd7, 0xda, 0x0c, 0x09, 0x4f, 0x08, 0xf0, 0x9b, 0x17, 0x07, 0x8f, 0x80, 0x0c, 0x1f, 0x3a,
    0x00, 0x9a, 0xe0, 0x3f, 0x04, 0x00, 0xe9, 0xcf, 0x2e, 0x0f, 0x1f, 0x00, 0x18, 0x30, 0x49,
    0x14, 0x1e, 0x86, 0x00, 0x57, 0xab, 0x04, 0x78, 0x4f, 0x07, 0xe2, 0x80, 0x1f, 0xae, 0x0f,
    0xbf, 0x00, 0x3f, 0x07, 0xe2, 0x80, 0x15, 0xa8, 0x07, 0xe0, 0x80, 0x17, 0xc2, 0x3e, 0x81,
    0xc8, 0x01, 0x82, 0x2b, 0x07, 0xe2, 0x80, 0x1e, 0xb9, 0x01, 0xdc, 0x06, 0x08, 0xaa, 0x83,
    0xf0, 0xc0, 0x13, 0xe1, 0x1f, 0xc1, 0xf8, 0xa0, 0x07, 0x80, 0x7e, 0x28, 0x01, 0x78, 0x39,
    0x00, 0x3e, 0x74, 0x00, 0xea, 0x83, 0xf1, 0x40, 0x0f, 0x30, 0x8a, 0xe0, 0x1c, 0x12, 0x42,
    0x40, 0xfc, 0x50, 0x02, 0xa6, 0x0e, 0x09, 0x2e, 0x70, 0xf0, 0x16, 0x5f, 0xcc, 0x9f, 0xec,
    0x04, 0xe1, 0xf2, 0x80, 0x60, 0x4e, 0x80, 0xb2, 0x08, 0xf1, 0x1f, 0x01, 0xf8, 0x20, 0x05,
    0xe0, 0xfc, 0x50, 0x02, 0xa0, 0x0e, 0x09, 0x2b, 0x80, 0xe0, 0xa2, 0x50, 0x8f, 0x53, 0x80,
    0xfc, 0x10, 0x02, 0xa2, 0x0e, 0x09, 0x38, 0x38, 0x24, 0x60, 0xe0, 0x92, 0x67, 0x1e, 0xef,
    0xff, 0xff, 0xff, 0xff, 0xff, 0x7f
};
static const nj_u1 m4v_sample_2[1513] = {
    0x00, 0x00, 0x01, 0xb6, 0x10, 0x03, 0x01, 0x8c, 0x0b, 0xfb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d,
    0xb6, 0xfe, 0x36, 0xdb, 0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0x36, 0xdb,
    0xf8, 0xdb, 0x6f, 0xe3, 0x6d, 0xbf, 0x8d, 0xb6, 0xfe, 0xd4, 0x64, 0x47, 0xc6, 0x00, 0xa7,
    0xea, 0xfc, 0x0e, 0x9b, 0x07, 0xcd, 0x80, 0x26, 0xc1, 0xe0, 0x7f, 0xc9, 0x68, 0x1e, 0x16,
    0x00, 0xf5, 0x60, 0x8c, 0xc8, 0x3e, 0x6c, 0x01, 0x66, 0xc7, 0x7a, 0x57, 0xf5, 0xaa, 0x3a,
    0x0c, 0x22, 0x03, 0xe7, 0x40, 0x4a, 0x69, 0x96, 0x41, 0x89, 0x01, 0xe2, 0xa0, 0x11, 0x07,
    0xce, 0x80, 0xc7, 0xee, 0x81, 0xe0, 0x7f, 0xbf, 0x68, 0x1e, 0x16, 0x01, 0x36, 0x41, 0x19,
    0x38, 0x3e, 0x6c, 0x02, 0x34, 0x0f, 0x03, 0xfd, 0x5a, 0x40, 0x78, 0x58, 0x05, 0x52, 0x83,
    0x02, 0x32, 0x70, 0x7c, 0xd8, 0x04, 0x6f, 0xff, 0x06, 0x24, 0x07, 0x8a, 0x80, 0x3c, 0x1f,
    0x3a, 0x02, 0xf5, 0x9b, 0x4e, 0x0c, 0x1b, 0x03, 0xc5, 0x40, 0x1f, 0xa0, 0xf9, 0xb0, 0x1c,
    0xfd, 0xf0, 0x78, 0x1f, 0xe9, 0x55, 0x03, 0xc2, 0xc0, 0x36, 0x5e, 0x08, 0xca, 0xc1, 0xf3,
    0x60, 0x11, 0x60, 0xf0, 0x3f, 0xd0, 0xa4, 0x07, 0x85, 0x80, 0x65, 0x28, 0x23, 0x2b, 0x07,
    0xcd, 0x80, 0x4e, 0xa9, 0x7d, 0x02, 0x00, 0xf1, 0x50, 0x07, 0x83, 0xe7, 0x40, 0x7a, 0xa5,
    0x64, 0x1e, 0x1a, 0x00, 0xf0, 0x78, 0xa8, 0x04, 0xc1, 0xf3, 0xa0, 0x3f, 0xfb, 0xe0, 0xf0,
    0x3f, 0xce, 0xaa, 0x07, 0x85, 0x80, 0x6d, 0x28, 0x23, 0x25, 0x07, 0xcd, 0x80, 0x5d, 0x83,
    0xc0, 0xff, 0x32, 0x90, 0x1e, 0x16, 0x01, 0xb4, 0xa3, 0x05, 0x60, 0xf9, 0xb0, 0x0a, 0xb2,
    0xd0, 0x60, 0x54, 0x03, 0xc5, 0x40, 0x22, 0x0f, 0x9d, 0x02, 0x1f, 0x2d, 0xa0, 0xf0, 0xb0,
    0x08, 0xc0, 0x78, 0x98, 0x05, 0x60, 0x3e, 0x6c, 0x08, 0x7e, 0x2f, 0xa0, 0x60, 0x45, 0xc0,
    0x60, 0xe3, 0x41, 0xc1, 0xe8, 0x3e, 0x6c, 0x01, 0x32, 0x0c, 0x06, 0xfc, 0x0c, 0x6b, 0xe0,
    0x8d, 0xf0, 0x7c, 0xd8, 0x01, 0xdf, 0x43, 0x60, 0x61, 0x70, 0x3e, 0x74, 0x02, 0xaf, 0xa1,
    0xb0, 0x30, 0xb8, 0x1f, 0x3a, 0x01, 0x5f, 0x17, 0xb0, 0x55, 0xc0, 0x21, 0xa0, 0xe2, 0x2c,
    0x0a, 0x78, 0x1c, 0x68, 0xbc, 0x24, 0xc3, 0x20, 0x61, 0x70, 0x3e, 0x74, 0x01, 0x70, 0x0e,
    0x40, 0x0f, 0x9d, 0x00, 0x5f, 0xdb, 0x05, 0x3c, 0x0e, 0x34, 0x5e, 0x12, 0x30, 0x45, 0x81,
    0xc6, 0x8c, 0x28, 0x49, 0x86, 0x42, 0xe0, 0x7c, 0xe8, 0x02, 0xf0, 0xc8, 0x5c, 0x0f, 0x9d,
    0x00, 0x5f, 0xdb, 0x04, 0x58, 0x6a, 0x8b, 0xc2, 0x49, 0x0f, 0xe1, 0xaa, 0x15, 0xa6, 0x0e,
    0x40, 0x0f, 0x9d, 0x00, 0x4e, 0x07, 0x20, 0x07, 0xce, 0x80, 0x27, 0xef, 0x08, 0x30, 0xd3,
    0xf0, 0x83, 0x0d, 0x3f, 0x03, 0x90, 0x03, 0xe7, 0x40, 0x12, 0x98, 0x39, 0x00, 0x3e, 0x74,
    0x01, 0x3f, 0x72, 0x5b, 0x09, 0x46, 0x99, 0x49, 0x48, 0xd2, 0x41, 0xf8, 0xa0, 0x07, 0x80,
    0x72, 0x00, 0x7c, 0xe8, 0x01, 0xfc, 0x54, 0xe5, 0x30, 0x94, 0x11, 0xa8, 0x49, 0x28, 0xc0,
    0x72, 0x20, 0x7c, 0xe8, 0x02, 0xd3, 0xc0, 0x72, 0x20, 0x7c, 0xe8, 0x02, 0x7c, 0x5f, 0x6d,
    0xc0, 0x7e, 0x08, 0x01, 0xcc, 0x6d, 0xa6, 0x85, 0xc0, 0xf9, 0xd0, 0x05, 0xaf, 0xbb, 0xc2,
    0x82, 0x80, 0x7c, 0xe8, 0x02, 0xd5, 0xfd, 0x80, 0xee, 0x03, 0xe7, 0x40, 0x1a, 0x5d, 0x17,
    0xd8, 0x39, 0x00, 0x3e, 0x74, 0x01, 0x3c, 0x1c, 0x80, 0x1f, 0x3a, 0x00, 0x9d, 0xc5, 0x81,
    0x60, 0x0f, 0x9d, 0x00, 0x4d, 0x03, 0x90, 0x03, 0xe7, 0x40, 0x12, 0xd0, 0x5f, 0xc1, 0xc8,
    0x01, 0xf3, 0xa0, 0x07, 0x60, 0xe4, 0x00, 0xf9, 0xd0, 0x03, 0xf0, 0x72, 0x00, 0x7c, 0xe8,
    0x01, 0xf0, 0x39, 0x00, 0x3e, 0x74, 0x00, 0xfd, 0x17, 0x30, 0x72, 0x00, 0x60, 0x89, 0x83,
    0xf1, 0x40, 0x0f, 0x05, 0x80, 0xfc, 0x10, 0x02, 0xd6, 0xce, 0x03, 0xc7, 0xc0, 0x06, 0x0c,
    0x11, 0x70, 0x5c, 0xa8, 0x3f, 0x14, 0x00, 0xef, 0xa0, 0xe5, 0x81, 0xf3, 0xa0, 0x07, 0xbd,
    0x59, 0x00, 0xb8, 0x1f, 0x3a, 0x00, 0x7a, 0x07, 0x20, 0x07, 0xce, 0x80, 0x26, 0x5b, 0x4c,
    0x1f, 0x8a, 0x00, 0x7c, 0x0e, 0x40, 0x0c, 0x11, 0x48, 0x39, 0x00, 0x3e, 0x74, 0x00, 0xe9,
    0x83, 0xf1, 0x40, 0x0f, 0x65, 0xb0, 0x7e, 0x28, 0x01, 0x70, 0x3f, 0x14, 0x00, 0xb8, 0x1f,
    0x8a, 0x00, 0x7a, 0x07, 0xe2, 0x80, 0x1f, 0xc5, 0x92, 0x0f, 0xc5, 0x00, 0x3c, 0x83, 0xf1,
    0x40, 0x0b, 0x20, 0xfc, 0x50, 0x03, 0xb0, 0x7e, 0x28, 0x01, 0xe5, 0xbf, 0xd0, 0x7e, 0x08,
    0x01, 0x60, 0x1f, 0x8a, 0x00, 0x5b, 0x07, 0x20, 0x07, 0xce, 0x80, 0x1d, 0x3f, 0x50, 0x7e,
    0x08, 0x01, 0xfc, 0x59, 0x20, 0xfc, 0x50, 0x02, 0xc0, 0x3f, 0x14, 0x00, 0xa5, 0xc1, 0xf8,
    0xa0, 0x05, 0x90, 0x7e, 0x28, 0x01, 0x5a, 0x0b, 0x2c, 0x1f, 0x8a, 0x00, 0x58, 0x07, 0x04,
    0x90, 0x0f, 0xc5, 0x00, 0x2c, 0x40, 0x7e, 0x18, 0x01, 0x78, 0x2f, 0xdc, 0x07, 0xe0, 0x80,
    0x17, 0x5c, 0x94, 0x1e, 0x3e, 0x00, 0x30, 0x60, 0x89, 0x20, 0x70, 0x48, 0x5f, 0x80, 0xe0,
    0xa3, 0xa2, 0xff, 0xce, 0x20, 0x07, 0xd9, 0x80, 0x15, 0x1a, 0x89, 0x10, 0xb8, 0x22, 0xfc,
    0x07, 0x05, 0x0f, 0x80, 0xe0, 0xa2, 0x62, 0xdb, 0x9e, 0x36, 0x0f, 0xb5, 0x00, 0x2c, 0x28,
    0x86, 0x81, 0xf6, 0x60, 0x05, 0xc0, 0xe0, 0x91, 0x83, 0xf1, 0x40, 0x0b, 0xcb, 0x80, 0x70,
    0x49, 0x76, 0x12, 0x03, 0xec, 0xc0, 0x0b, 0xc1, 0xc1, 0x24, 0x03, 0x82, 0x4e, 0x8b, 0xd2,
    0xb2, 0x9a, 0x07, 0xd9, 0x80, 0x14, 0xd6, 0xc0, 0x72, 0xc0, 0xf9, 0xd0, 0x04, 0x94, 0x07,
    0x04, 0x8a, 0xeb, 0x5d, 0x07, 0xde, 0x80, 0x15, 0x68, 0xbe, 0x22, 0xe0, 0xf1, 0xf0, 0x01,
    0x83, 0xe7, 0x40, 0x0f, 0x5c, 0xe0, 0x3e, 0xf4, 0x00, 0xb7, 0x8c, 0x15, 0x82, 0xc0, 0x18,
    0x22, 0x4f, 0xeb, 0x20, 0x07, 0x10, 0x5c, 0x5e, 0xc1, 0xf8, 0xa0, 0x05, 0xa5, 0xc1, 0xf7,
    0xe0, 0x05, 0xae, 0x12, 0x03, 0x88, 0x31, 0x61, 0x40, 0x38, 0x8a, 0x51, 0x7f, 0xe8, 0x3f,
    0x04, 0x00, 0xaa, 0x74, 0x1f, 0x82, 0x00, 0x55, 0xae, 0x60, 0x3b, 0x81, 0x12, 0xda, 0x0f,
    0xc3, 0x00, 0x3f, 0x8b, 0xd4, 0xe8, 0x3f, 0x04, 0x00, 0xa9, 0x4a, 0x0f, 0xc1, 0x00, 0x2d,
    0x03, 0xf1, 0x40, 0x0e, 0x62, 0x2c, 0x0f, 0xbd, 0x00, 0x3d, 0x82, 0xd4, 0x3a, 0x0e, 0x0a,
    0x10, 0x07, 0x04, 0x85, 0xe5, 0x07, 0xe0, 0x80, 0x14, 0xa8, 0x38, 0x24, 0x58, 0x2d, 0xa0,
    0x70, 0x49, 0x40, 0xe0, 0x92, 0x01, 0xc1, 0x24, 0x03, 0x82, 0x4b, 0x44, 0xee, 0xc0, 0xe0,
    0x93, 0x60, 0x70, 0x49, 0x60, 0xb5, 0x83, 0x82, 0x4a, 0x07, 0x04, 0x9c, 0x1c, 0x12, 0x30,
    0x70, 0x49, 0xd1, 0x6e, 0x07, 0x04, 0x8c, 0x1c, 0x12, 0x70, 0x70, 0x48, 0xc1, 0xc1, 0x27,
    0x45, 0xcc, 0x1c, 0x12, 0x31, 0x90, 0x38, 0x82, 0x41, 0xc1, 0x25, 0x03, 0x82, 0x4f, 0xb6,
    0x32, 0x07, 0x10, 0x17, 0x19, 0x03, 0x88, 0x18, 0x38, 0x24, 0x60, 0xe0, 0x91, 0xa5, 0xf0,
    0x70, 0x48, 0xc1, 0xc1, 0x23, 0x07, 0x04, 0x8f, 0x80, 0xe0, 0xa3, 0xef, 0x83, 0x82, 0x4f,
    0xc0, 0x7e, 0x08, 0x01, 0x64, 0x1c, 0x12, 0x70, 0x70, 0x49, 0xa8, 0xbd, 0x3a, 0xd0, 0x3f,
    0x04, 0x00, 0xa5, 0xb5, 0x8e, 0xa0, 0x17, 0x03, 0xe7, 0x40, 0x0e, 0x5c, 0x1c, 0x12, 0x11,
    0x07, 0xe2, 0x80, 0x15, 0x18, 0x5e, 0x64, 0x71, 0x41, 0xf7, 0xe0, 0x09, 0xa5, 0x00, 0xe5,
    0x81, 0xf3, 0xa0, 0x09, 0xb2, 0xc0, 0x7e, 0x08, 0x01, 0x54, 0xad, 0x03, 0x96, 0x06, 0x08,
    0x97, 0x17, 0xaf, 0x3c, 0x0e, 0x58, 0x1f, 0x3a, 0x00, 0x7b, 0x80, 0xfc, 0x30, 0x02, 0xac,
    0xa2, 0xe2, 0x00, 0x7d, 0x98, 0x01, 0x77, 0x01, 0xc1, 0x46, 0xc2, 0xc4, 0x81, 0xc1, 0x22,
    0x80, 0xe0, 0x91, 0xf0, 0x1c, 0x14, 0x6e, 0x68, 0x38, 0x2a, 0x65, 0x13, 0xad, 0x83, 0x82,
    0x46, 0xc1, 0xc1, 0x27, 0x8b, 0x78, 0x38, 0x24, 0xe0, 0xe0, 0x93, 0x03, 0x82, 0x4c, 0x0e,
    0x09, 0x3c, 0x5b, 0x81, 0xc1, 0x26, 0x07, 0x04, 0x98, 0x1c, 0x12, 0x60, 0x70, 0x49, 0xf7,
    0x40, 0xe0, 0x93, 0x03, 0x82, 0x46, 0x0e, 0x09, 0x30, 0x38, 0x24, 0x9d, 0xcf, 0x01, 0xc1,
    0x43, 0x07, 0x04, 0x98, 0x1c, 0x12, 0x30, 0x70, 0x49, 0xf6, 0xc1, 0xc1, 0x27, 0x07, 0x04,
    0x8c, 0x1c, 0x12, 0x70, 0x70, 0x49, 0x7b, 0xc0, 0xe0, 0x93, 0x83, 0x82, 0x46, 0x0e, 0x09,
    0x30, 0x38, 0x24, 0x98, 0xba, 0x41, 0xc1, 0x22, 0x20, 0xe0, 0x92, 0x41, 0xc1, 0x23, 0xe0,
    0x38, 0x28, 0x75, 0x17, 0xbe, 0x03, 0x82, 0x86, 0x0e, 0x09, 0x32, 0x80, 0x70, 0x51, 0x07,
    0xa6, 0x28, 0x59, 0x67, 0x50, 0x03, 0xec, 0xc0, 0x0b, 0x31, 0x54, 0x07, 0x05, 0x4f, 0x83,
    0x82, 0x4d, 0x45, 0x4a, 0x05, 0x8e, 0x9a, 0x07, 0x04, 0x98, 0x1c, 0x12, 0x5e, 0xf0, 0x38,
    0x24, 0xc0, 0xe0, 0x93, 0x03, 0x82, 0x49, 0x07, 0x04, 0x9d, 0x17, 0x48, 0x38, 0x24, 0x90,
    0x70, 0x49, 0x40, 0xe0, 0x92, 0x41, 0xc1, 0x27, 0x8b, 0x98, 0x38, 0x24, 0xc0, 0xe0, 0x91,
    0x83, 0x82, 0x49, 0x07, 0x04, 0x9e, 0x2d, 0x90, 0x70, 0x49, 0xc1, 0xc1, 0x27, 0x07, 0x04,
    0x94, 0x0e, 0x09, 0x26, 0x2e, 0x90, 0x70, 0x49, 0x40, 0xe0, 0x93, 0x03, 0x82, 0x49, 0xe0,
    0x38, 0x28, 0xf1, 0x64, 0x83, 0x82, 0x4e, 0x0e, 0x09, 0x18, 0x38, 0x24, 0x83, 0xcd, 0x89,
    0x95, 0x55, 0x52, 0xd6, 0xa5, 0x29, 0x80, 0x8d, 0xb7, 0x00, 0x84, 0x47, 0xc2, 0x64, 0x94,
    0x03, 0x82, 0x82, 0xf9, 0xec, 0xf2, 0xd9, 0x38, 0xbd, 0xa3, 0x3d, 0xaa, 0x68, 0xbd, 0xf1,
    0x60, 0xab, 0x90, 0xb3, 0x50, 0x38, 0x24, 0xb0, 0x70, 0x49, 0x31, 0x77, 0xe8, 0x38, 0x28,
    0xb0, 0x70, 0x49, 0xb8, 0x0e, 0x0a, 0x24, 0x1c, 0x12, 0x78, 0xb1, 0x83, 0x82, 0x47, 0xc0,
    0x70, 0x51, 0x81, 0xc1, 0x23, 0x07, 0x04, 0x8d, 0x89, 0x9d, 0xc0, 0x70, 0x51, 0x20, 0xe0,
    0x91, 0x83, 0x82, 0x4d, 0x78, 0x7b, 0x83, 0x82, 0x4d, 0xdb, 0x14, 0x50, 0x0e, 0x09, 0x28,
    0x1c, 0x12, 0x4b, 0x3d, 0x14, 0x48, 0xc4, 0x80, 0xe0, 0xa3, 0x70, 0x1c, 0x14, 0x3d, 0xd1,
    0x47, 0x56, 0x03, 0x82, 0x8c, 0x0e, 0x09, 0x3f, 0xe0, 0x2e, 0x9b, 0x91, 0x83, 0x82, 0x48,
    0x07, 0x04, 0x99, 0xf0, 0x52, 0x66, 0xcf, 0x33, 0xd7, 0x9b, 0x83, 0x82, 0x4b, 0x07, 0x04,
    0x98, 0xf3, 0xf1, 0x21, 0xb8, 0x0e, 0x0a, 0x13, 0x07, 0x04, 0x8f, 0x76, 0x4c, 0x0e, 0x09,
    0x18, 0x38, 0x24, 0x6d, 0xb8, 0xf3, 0x6f, 0xc4, 0x66, 0x6d, 0xfc, 0x6f, 0x37, 0x78, 0xdb,
    0x6d, 0xb8, 0xdb, 0x6f, 0x91, 0xcb, 0x6f, 0xc4, 0x63, 0x6d, 0xfc, 0x6d, 0xb7, 0xf1, 0xb6,
    0xdf, 0xc6, 0xdb, 0x7f, 0x1b, 0x6d, 0xf8, 0x8c, 0x6d, 0xbf, 0x8d, 0xb6, 0xfd
};
static const nj_u1 m4v_sample_3[1210] = {
    0x00, 0x00, 0x01, 0xb6, 0x50, 0xa3, 0x82, 0x1f, 0xfe, 0x67, 0x80, 0x1b, 0xd8, 0x4b, 0xe1,
    0xef, 0x81, 0x34, 0xbb, 0xe6, 0x41, 0xf0, 0x20, 0x15, 0x33, 0x80, 0x0c, 0x43, 0xb2, 0xe0,
    0x54, 0x81, 0x0a, 0x2c, 0x03, 0xaa, 0x81, 0x93, 0x81, 0x0a, 0x2c, 0x00, 0xc4, 0x40, 0xaa,
    0x07, 0xce, 0x80, 0x3c, 0x1e, 0x02, 0x01, 0xb4, 0x40, 0xaa, 0x07, 0xce, 0x80, 0x44, 0xce,
    0x00, 0x32, 0xf0, 0x1f, 0x54, 0x05, 0xc6, 0x9e, 0x03, 0xea, 0x80, 0xb8, 0xd0, 0x1e, 0x02,
    0x01, 0xd0, 0xe8, 0x1f, 0x3a, 0x00, 0x70, 0x78, 0x08, 0x08, 0x41, 0xf8, 0xa0, 0x09, 0x33,
    0xb2, 0xe0, 0x43, 0xf2, 0x70, 0x8c, 0xb8, 0x10, 0xfc, 0x9c, 0x68, 0x0f, 0x81, 0x00, 0xf8,
    0x3e, 0x04, 0x03, 0xe9, 0xca, 0x01, 0xf2, 0xe5, 0x8b, 0xd0, 0x51, 0x67, 0x80, 0xfa, 0xa0,
    0x54, 0x81, 0x0a, 0x2c, 0x07, 0x80, 0x80, 0x75, 0x10, 0x2a, 0x81, 0xf3, 0xa0, 0x0f, 0x07,
    0x80, 0x80, 0x75, 0x11, 0x60, 0x3e, 0x74, 0x01, 0xe6, 0x60, 0x01, 0xca, 0x01, 0xf2, 0xe0,
    0x64, 0xe8, 0x28, 0x30, 0xb2, 0x01, 0xf2, 0xe0, 0x54, 0x81, 0x0a, 0x2c, 0x07, 0x80, 0x80,
    0x7f, 0x13, 0x02, 0xa8, 0x1f, 0x3a, 0x01, 0x10, 0x78, 0x08, 0x07, 0x51, 0x02, 0xa8, 0x1f,
    0x3a, 0x01, 0x13, 0x3c, 0x00, 0xeb, 0xc3, 0xdf, 0x01, 0x71, 0xa7, 0x80, 0xff, 0x80, 0xb8,
    0xd0, 0x03, 0x01, 0xf8, 0xa0, 0x07, 0x00, 0xc0, 0x60, 0x59, 0x19, 0xa0, 0x07, 0x20, 0x3a,
    0xa8, 0x15, 0x20, 0x42, 0x8b, 0x00, 0xea, 0xa0, 0x54, 0x81, 0x0a, 0x2c, 0x04, 0x04, 0x40,
    0xaa, 0x07, 0xce, 0x80, 0x34, 0x03, 0x91, 0x02, 0xa8, 0x1f, 0x3a, 0x00, 0xd3, 0x3b, 0x54,
    0x07, 0xe2, 0x71, 0xa2, 0xa1, 0xeb, 0x81, 0xf0, 0x20, 0x17, 0x07, 0xc0, 0x80, 0x5c, 0xcc,
    0x00, 0x3a, 0x8a, 0x62, 0x71, 0xa7, 0x62, 0x71, 0xa0, 0x90, 0x0c, 0x0b, 0x21, 0x28, 0x18,
    0x16, 0x48, 0xc0, 0x0e, 0x26, 0x93, 0x8d, 0x15, 0x03, 0x02, 0xca, 0x40, 0x58, 0x04, 0x78,
    0x5a, 0xf8, 0x3f, 0x0c, 0x00, 0xa6, 0xed, 0x07, 0xe0, 0x80, 0x15, 0x5d, 0xde, 0x23, 0x0c,
    0x81, 0x82, 0x25, 0x36, 0xc0, 0x7d, 0xf8, 0x01, 0xcb, 0x60, 0x8f, 0xa0, 0x7e, 0x28, 0x01,
    0x68, 0x1f, 0x8a, 0x00, 0x5d, 0xc0, 0x7e, 0x08, 0x01, 0x6a, 0x83, 0xf0, 0xc0, 0x0b, 0x60,
    0x47, 0x58, 0x3f, 0x14, 0x00, 0xac, 0x1f, 0x8a, 0x00, 0x5a, 0x07, 0xe2, 0x80, 0x16, 0x41,
    0xf8, 0xa0, 0x05, 0xb8, 0x47, 0x48, 0x3f, 0x14, 0x00, 0xb7, 0x41, 0xf8, 0x60, 0x05, 0x92,
    0xca, 0x0f, 0xbf, 0x00, 0x2e, 0xd9, 0xc0, 0x7d, 0xe8, 0x01, 0x66, 0x11, 0xea, 0x03, 0xf1,
    0x40, 0x0b, 0xd4, 0x83, 0xf0, 0x40, 0x0a, 0xad, 0x28, 0x17, 0x03, 0xe7, 0x40, 0x0f, 0x60,
    0xfc, 0x50, 0x03, 0xab, 0x04, 0x62, 0x20, 0xfc, 0x50, 0x02, 0xe0, 0x7e, 0x28, 0x01, 0x52,
    0x94, 0x1f, 0x82, 0x00, 0x74, 0x81, 0xf8, 0xa0, 0x05, 0x68, 0x1b, 0xc0, 0xfc, 0x50, 0x02,
    0xe0, 0x7e, 0x28, 0x01, 0x58, 0x3f, 0x14, 0x00, 0xb4, 0x0f, 0xc5, 0x00, 0x2f, 0x4d, 0xc0,
    0x1c, 0x04, 0x15, 0x43, 0xe0, 0x10, 0x65, 0x10, 0x12, 0x37, 0x1f, 0xe0, 0xac, 0xcc, 0x85,
    0x43, 0xca, 0x8f, 0x7d, 0x41, 0x2d, 0xae, 0x46, 0x10, 0x05, 0x9c, 0x01, 0x2e, 0x32, 0x40,
    0x78, 0x0c, 0xaa, 0x3c, 0x10, 0x15, 0xfb, 0xcf, 0xf1, 0xb3, 0x24, 0x00, 0xc0, 0x12, 0x24,
    0x43, 0x83, 0xef, 0x9e, 0x71, 0xca, 0xc0, 0x24, 0x21, 0x42, 0xe2, 0x72, 0xe9, 0xe8, 0xe3,
    0x34, 0x0f, 0x00, 0x48, 0x64, 0xa9, 0x5a, 0xa8, 0x01, 0x05, 0xd1, 0xff, 0x0c, 0x81, 0x8f,
    0x05, 0x01, 0x70, 0x0e, 0xbb, 0x4c, 0x03, 0xc0, 0x40, 0x62, 0xaf, 0xca, 0x3f, 0x2b, 0xe7,
    0x95, 0x86, 0x2a, 0x8b, 0xc7, 0xde, 0x00, 0xb7, 0x84, 0x7d, 0xe7, 0x35, 0x10, 0x64, 0x0f,
    0x9d, 0x00, 0x3a, 0xab, 0xc0, 0x7d, 0xe8, 0x01, 0xca, 0x30, 0x5c, 0x1e, 0x83, 0xee, 0xc0,
    0x0a, 0x9b, 0x7c, 0x9b, 0xcb, 0x05, 0xdd, 0x06, 0x09, 0x8a, 0x70, 0x8f, 0x80, 0x7e, 0x28,
    0x01, 0x55, 0x52, 0x6e, 0x03, 0xec, 0xc0, 0x0f, 0x8b, 0x0d, 0x60, 0xb8, 0x22, 0xba, 0xa8,
    0xa0, 0x1f, 0x62, 0x00, 0x55, 0xa1, 0x1e, 0xd4, 0xcb, 0xde, 0x06, 0x40, 0xc1, 0x12, 0xc5,
    0xa4, 0x82, 0xe0, 0x7c, 0xe8, 0x01, 0xce, 0x7f, 0xde, 0xc3, 0x63, 0x2c, 0x06, 0x08, 0x8d,
    0xf4, 0x1f, 0x82, 0x00, 0x79, 0x84, 0x7a, 0x85, 0xa0, 0xfc, 0x10, 0x02, 0x95, 0xcd, 0x07,
    0xe0, 0x80, 0x16, 0x81, 0xf8, 0xa0, 0x07, 0x3b, 0xea, 0x6c, 0x1f, 0x6a, 0x00, 0x76, 0x53,
    0x44, 0x16, 0x0f, 0xef, 0x1d, 0xa7, 0x8c, 0x69, 0x81, 0x0d, 0x37, 0x0f, 0xb8, 0x22, 0x10,
    0xb7, 0x41, 0xc1, 0x35, 0x83, 0x82, 0x46, 0xc1, 0xc1, 0x22, 0x50, 0x8d, 0xb0, 0x70, 0x49,
    0xc1, 0xc1, 0x26, 0x07, 0x04, 0x96, 0x0e, 0x09, 0x3c, 0x37, 0x00, 0xe0, 0x93, 0x83, 0x82,
    0x4a, 0x07, 0x04, 0x8c, 0x1c, 0x12, 0x5c, 0x37, 0xc1, 0xc1, 0x23, 0x19, 0x03, 0x88, 0x38,
    0x38, 0x24, 0xe0, 0xe0, 0x93, 0xa1, 0xbc, 0x32, 0x07, 0x10, 0x70, 0x25, 0x01, 0xc4, 0x5d,
    0x08, 0x3e, 0xec, 0x00, 0xb2, 0x0e, 0x09, 0x24, 0x08, 0xea, 0x44, 0x80, 0x1c, 0x40, 0xc1,
    0xc1, 0x23, 0x07, 0x04, 0x98, 0x1c, 0x12, 0x58, 0x98, 0x38, 0x04, 0xa1, 0x3f, 0xb8, 0x77,
    0xda, 0x19, 0x17, 0x69, 0x30, 0x0a, 0x78, 0x12, 0x05, 0xc0, 0xe1, 0xc0, 0x0c, 0x56, 0x10,
    0x83, 0x18, 0x3d, 0x3b, 0x14, 0xe8, 0xa5, 0xee, 0x08, 0xf1, 0x98, 0xe3, 0x4d, 0x0b, 0x81,
    0xf3, 0xa0, 0x09, 0x5b, 0x94, 0x1d, 0xc0, 0x7c, 0xe8, 0x02, 0x44, 0x62, 0x00, 0x3f, 0x04,
    0x00, 0xa6, 0x9b, 0x60, 0xd4, 0x17, 0x03, 0xe7, 0x40, 0x0e, 0x51, 0x86, 0x78, 0x48, 0x11,
    0x00, 0xc5, 0x52, 0xf8, 0x50, 0xe1, 0xf1, 0x72, 0xc7, 0x87, 0xf0, 0xba, 0xe6, 0x00, 0xb3,
    0x34, 0x10, 0x82, 0xd5, 0xe1, 0x97, 0xfd, 0xc1, 0x1d, 0xfa, 0x3f, 0x55, 0x38, 0xe0, 0x88,
    0x64, 0x1c, 0x12, 0x60, 0x70, 0x49, 0xb0, 0x38, 0x24, 0x98, 0x46, 0xd8, 0x38, 0x24, 0x60,
    0xe0, 0x91, 0x83, 0x82, 0x4c, 0x0e, 0x09, 0x2d, 0x0d, 0xd0, 0x38, 0x24, 0xc0, 0xe0, 0x91,
    0x83, 0x82, 0x49, 0x07, 0x04, 0x93, 0x0d, 0xf0, 0x70, 0x49, 0x81, 0xc1, 0x23, 0x07, 0x04,
    0x98, 0x1c, 0x12, 0x2d, 0x08, 0xc9, 0xe0, 0x38, 0x28, 0xc0, 0xe0, 0x92, 0x41, 0xc1, 0x22,
    0x80, 0xe0, 0x93, 0x60, 0xdb, 0x07, 0x04, 0x9c, 0x1c, 0x12, 0x40, 0x38, 0x24, 0xdc, 0x07,
    0x05, 0x16, 0x06, 0xc2, 0xe0, 0x38, 0x24, 0xe0, 0xe0, 0x93, 0x83, 0x82, 0x47, 0xc0, 0x70,
    0x50, 0x5b, 0x99, 0xe0, 0x58, 0x08, 0xb8, 0xe9, 0xc6, 0x9c, 0x66, 0x82, 0xff, 0x7b, 0xcf,
    0x2f, 0xf2, 0x88, 0xd8, 0x0d, 0x80, 0x12, 0xa8, 0xd8, 0x47, 0x85, 0xb2, 0xa8, 0x41, 0xcb,
    0x41, 0xc1, 0x45, 0xf0, 0x1c, 0x14, 0x7e, 0x03, 0x82, 0x82, 0xdc, 0xc9, 0x81, 0xb0, 0x13,
    0xff, 0xf4, 0xca, 0xa0, 0x08, 0x87, 0xcd, 0x50, 0x03, 0x00, 0x4b, 0x9c, 0x11, 0xa1, 0x6c,
    0x1c, 0x12, 0x48, 0x38, 0x24, 0x90, 0x70, 0x49, 0x40, 0xe0, 0x91, 0x20, 0x47, 0xd0, 0x38,
    0x24, 0xc0, 0xe0, 0x93, 0x83, 0x82, 0x48, 0xc0, 0x70, 0x4d, 0xd0, 0x8c, 0x8e, 0x03, 0x82,
    0x8a, 0x07, 0x04, 0x89, 0x05, 0x8a, 0xdc, 0x07, 0x05, 0x1e, 0x11, 0xad, 0x18, 0x38, 0x68,
    0x97, 0x01, 0xc1, 0x47, 0x80, 0xe0, 0x99, 0x30, 0x70, 0x49, 0x30, 0x8f, 0xc0, 0xe0, 0x92,
    0x14, 0x03, 0x82, 0x86, 0x0e, 0x09, 0x24, 0xfb, 0xc3, 0x18, 0xc0, 0x24, 0x74, 0xe0, 0xc8,
    0x02, 0x83, 0x61, 0x64, 0x1c, 0x12, 0x7e, 0x03, 0x82, 0x88, 0x07, 0x04, 0x8c, 0x1c, 0x12,
    0x16, 0xc1, 0x1b, 0x94, 0x03, 0x82, 0x8c, 0xa0, 0x1c, 0x14, 0x30, 0x70, 0x49, 0x81, 0xc1,
    0x25, 0xc2, 0x39, 0xf0, 0x1c, 0x14, 0x60, 0x70, 0x48, 0xc1, 0xc1, 0x26, 0xe0, 0x38, 0x28,
    0xd4, 0x20, 0x58, 0x58, 0x07, 0x04, 0x92, 0xe5, 0x29, 0xd2, 0x00, 0x60, 0x5c, 0x32, 0x4c,
    0x0c, 0x00, 0x90, 0xc8, 0x02, 0xae, 0x3a, 0xe3, 0x8c, 0xf0, 0x4c, 0x04, 0x83, 0x3a, 0x43,
    0x8f, 0x38, 0x66, 0xe7, 0x44, 0xa5, 0x74, 0xc4, 0x00, 0x85, 0x40, 0x85, 0xe0, 0x4c, 0x33,
    0xc0, 0x0e, 0x0b, 0x89, 0x41, 0x90, 0x30, 0x65, 0xe1, 0xe3, 0x87, 0x4e, 0x0d, 0x85, 0xa0,
    0x70, 0x48, 0x99, 0xe2, 0xca, 0x1d, 0x8f, 0x25, 0x33, 0x70, 0x67, 0x03, 0x3a, 0x1e, 0x80,
    0x10, 0x65, 0x00, 0x0c, 0x02, 0x7c, 0x78, 0x02, 0x8e, 0x25, 0x80, 0x90, 0xc8, 0x32, 0x38,
    0xd8, 0x01, 0xc0, 0x4b, 0x8f, 0x40, 0xf8, 0x04, 0xff, 0xf7
};

static const nj_u4 m4v_sample_sizes[4] = {
    286, 426, 1513, 1210
};

/* FNV-1a of the reference Y, U and V planes, frames 1 and 3. */
static const nj_u4 m4v_ref_hash[2][3] = {
    { 0xfd58c2f1u, 0x8c0adcc5u, 0x0848e1c5u },  /* frame 1, first P-VOP        */
    { 0x33be5348u, 0x3d84e04au, 0x6a5683dau }   /* frame 3, 4MV and intra MBs  */
};

/* One reference luma row per frame, for a failure that names a pixel. */
static const nj_u1 m4v_ref_row_1[8] = {
    31, 32, 34, 37, 40, 42, 44, 45
};
static const nj_u1 m4v_ref_row_3[8] = {
    198, 200, 206, 212, 220, 226, 232, 236
};

static int parse_cfg(const nj_u1 *b, nj_u4 n, nj_m4v_vol *vol)
{
    nj_u4 code = 0, pos = 0, from = 0;

    while (nj_m4v_start_code(b, n, from, &code, &pos)) {
        if (code == NJ_M4V_VOL) {
            return nj_m4v_parse_vol(b, n, pos, vol);
        }
        from = pos;
    }
    return 0;
}


/* Small accounting allocator for the provider test: open/close must balance.
 * The payload is 16-byte aligned like the VM's own host allocations (the
 * provider state and nj_mp4 hold 8-byte fields), so UBSan checks it honestly. */
typedef struct m4v_test_hdr {
    nj_u4 n;
} m4v_test_hdr;

#define M4V_TEST_ALIGN 16u

static unsigned long m4v_test_live;

static void *m4v_test_alloc(void *ud, nj_u4 n)
{
    m4v_test_hdr *h;
    size_t         pad = (sizeof(m4v_test_hdr) + M4V_TEST_ALIGN - 1u) &
                         ~(size_t)(M4V_TEST_ALIGN - 1u);

    (void)ud;
    h = (m4v_test_hdr *)malloc(pad + (size_t)n);
    if (h == NULL) {
        return NULL;
    }
    h->n = n;
    m4v_test_live += n;
    return (void *)((nj_u1 *)h + pad);
}

static void m4v_test_free(void *ud, void *p)
{
    m4v_test_hdr *h;
    size_t         pad = (sizeof(m4v_test_hdr) + M4V_TEST_ALIGN - 1u) &
                         ~(size_t)(M4V_TEST_ALIGN - 1u);

    (void)ud;
    if (p == NULL) {
        return;
    }
    h = (m4v_test_hdr *)((nj_u1 *)p - pad);
    m4v_test_live -= h->n;
    free(h);
}

int main(void)
{
    nj_m4v_vol vol;
    nj_u4 code = 0, pos = 0;

    ok(nj_m4v_start_code(cfg_1942, (nj_u4)sizeof(cfg_1942), 0u, &code, &pos) == 1 &&
       code == NJ_M4V_VOS, "the first start code of the 1942 config is VOS");

    ok(parse_cfg(cfg_1942, (nj_u4)sizeof(cfg_1942), &vol) == 1,
       "the 1942 decoder config parses");
    ok(vol.width == 176u && vol.height == 144u, "1942 is 176x144");
    ok(vol.time_res == 1000u, "1942 counts 1000 increments per second");
    ok(vol.shape == 0, "1942 is a rectangular layer");
    ok(vol.complexity_disabled == 1,
       "the 1942 VOL disables complexity estimation");
    ok(vol.cplx_i == 0 && vol.cplx_p == 0 && vol.cplx_b == 0,
       "so no I/P/B-VOP complexity bits are promised");

    ok(parse_cfg(cfg_doom, (nj_u4)sizeof(cfg_doom), &vol) == 1,
       "the doom decoder config parses");
    ok(vol.width == 320u && vol.height == 240u, "doom is 320x240");

    ok(nj_m4v_accepts(cfg_1942, (nj_u4)sizeof(cfg_1942)) == 1,
       "the 1942 config is recognised as M4V");
    ok(nj_m4v_accepts(cfg_doom, (nj_u4)sizeof(cfg_doom)) == 1,
       "the doom config is recognised as M4V");

    /* A truncated config must be refused, not read past the buffer. */
    ok(nj_m4v_parse_vol(cfg_1942, 24u, 22u, &vol) == 0,
       "a truncated VOL is refused");

    {
        static const nj_u1 junk[12] = { 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12 };
        ok(nj_m4v_accepts(junk, (nj_u4)sizeof(junk)) == 0, "noise is not M4V");
    }

    {
        /* First video sample of 1942.3gp: a VOP header at time 0. */
        static const nj_u1 vop_i[] = {
            0x00, 0x00, 0x01, 0xb6, 0x10, 0x03, 0x09, 0x8c, 0x21, 0xb6, 0xfe, 0x36
        };
        nj_m4v_vop vop;

        {
            nj_u4 end = 32u;

            ok(nj_m4v_parse_vop(vop_i, (nj_u4)sizeof(vop_i), 4u, 1000u, &vop) == 1,
               "the 1942 VOP header parses");
            ok(nj_m4v_parse_vop_bits(vop_i, (nj_u4)sizeof(vop_i), &end, 1000u, &vop) == 1,
               "the same header parses bit by bit");
            ok(end == 56u,
               "a rectangular I-VOP header ends at bit 56: change_CR_disable and "
               "constant_alpha belong to non-rectangular shapes only");
            ok(vop.qscale == 9u, "the first 1942 VOP carries quantiser 9");
            ok(vop.dc_vlc_thr == 0u, "and an intra_dc_vlc_thr of 0");
        }
        ok(vop.qscale >= 1 && vop.qscale <= 31 && vop.dc_vlc_thr <= 7,
           "and it carries a usable quantiser and DC threshold");
        ok(vop.type == 0, "the first sample is an I-VOP");
        ok(vop.time_increment == 0u, "it sits at time increment 0");
        ok(vop.coded == 1, "the frame is coded, not skipped");
    }
    {
        /* First P-VOP of 1942.3gp: vop_coded is followed by the one rounding
         * bit a P-VOP carries, and vop_fcode_forward comes after the
         * quantiser, not before it. */
        static const nj_u1 vop_p[] = {
            0x00, 0x00, 0x01, 0xb6, 0x50, 0xa3, 0x82, 0x1f, 0xfe, 0xb7
        };
        nj_m4v_vop vop;
        nj_u4 end = 32u;

        ok(nj_m4v_parse_vop_bits(vop_p, (nj_u4)sizeof(vop_p), &end, 1000u, &vop) == 1,
           "the P-VOP header of the 1942 clip parses");
        ok(vop.type == 1, "and it really is a P-VOP");
        ok(end == 60u, "its header ends at bit 60 once rounding and fcode are read in the right place");
        ok(vop.qscale == 4u, "with quantiser 4, not the 16 a misread header produced");
        ok(vop.dc_vlc_thr == 0u, "and an intra_dc_vlc_thr of 0");
    }
    {
        /* doom.3gp opens with a group of VOPs; the VOP follows it. */
        static const nj_u1 gop[] = {
            0x00, 0x00, 0x01, 0xb3, 0x00, 0x10, 0x07, 0x00, 0x00, 0x01, 0xb6, 0x10,
            0x03, 0x09, 0x00, 0x00, 0x00, 0x00
        };
        nj_u4 pos = 0;
        nj_m4v_vop vop;

        ok(nj_m4v_find_vop(gop, (nj_u4)sizeof(gop), &pos) == 1,
           "the VOP after the GOP header is found");
        ok(nj_m4v_parse_vop(gop, (nj_u4)sizeof(gop), pos, 1000u, &vop) == 1 &&
           vop.type == 0 && vop.coded == 1,
           "the doom VOP header parses as a coded I-VOP");
    }


    /* The intra VLC tables are generated from the reference decoder's data.
       Check the invariants a prefix code must have rather than magic numbers:
       unique codewords, every symbol once, and each codeword covering exactly
       the 2^(12-len) entries of the 12-bit lookup it owns. */
    ok(nj_m4v_dc_lum[0].len == 3u && nj_m4v_dc_lum[0].size == 0u,
       "DC luma size 0 is a 3-bit code");
    ok(nj_m4v_dc_chrom[0].len == 2u && nj_m4v_dc_chrom[0].size == 0u,
       "DC chroma size 0 is a 2-bit code");
    {
        int seen[256];
        int i, bad = 0, syms = 0, covered = 0;

        memset(seen, 0, sizeof(seen));
        for (i = 0; i < 4096; i++) {
            nj_u4 e = nj_m4v_ac_lut[i];

            if (e == 0xffffu) {
                continue;
            }
            {
                int len = (int)(e >> 8), sym = (int)(e & 0xffu);
                covered++;
                if (len < 1 || len > NJ_M4V_AC_BITS || sym >= NJ_M4V_AC_SYMS) {
                    bad++;
                    continue;
                }
                if (seen[sym] == 0) {
                    syms++;
                }
                seen[sym]++;
            }
        }
        ok(bad == 0, "every AC lookup entry names a valid symbol and length");
        ok(syms == NJ_M4V_AC_SYMS, "all AC symbols appear in the lookup");
    }
    {
        int i, bad = 0, found = 0;

        for (i = 0; i < NJ_M4V_AC_SYMS; i++) {
            int j, idx = -1;
            nj_u4 pos = 0;
            int   last = 0, sym;

            for (j = 0; j < 4096; j++) {
                nj_u4 e = nj_m4v_ac_lut[j];
                if (e != 0xffffu && (int)(e & 0xffu) == i) {
                    idx = j;
                    break;
                }
            }
            if (idx < 0) {
                continue;
            }
            found++;
            {
                nj_u1 buf[4];
                int   len = (int)(nj_m4v_ac_lut[idx] >> 8);

                memset(buf, 0, sizeof(buf));
                for (j = 0; j < len; j++) {
                    if ((idx >> (NJ_M4V_AC_BITS - 1 - j)) & 1) {
                        buf[j / 8] |= (nj_u1)(0x80u >> (j % 8));
                    }
                }
                sym = nj_m4v_decode_ac(buf, (nj_u4)sizeof(buf), &pos, &last);
                if (sym != i || (int)pos != len) {
                    bad++;
                }
                if (sym >= 0 && last != (sym >= NJ_M4V_AC_LAST)) {
                    bad++;
                }
            }
        }
        ok(found == NJ_M4V_AC_SYMS, "every AC symbol has a codeword to test");
        ok(bad == 0, "every AC codeword round-trips through the decoder");
    }

    {
        int i, bad = 0;

        for (i = 0; i < 13; i++) {
            int which;

            for (which = 0; which < 2; which++) {
                const nj_m4v_dc_entry *tab = which ? nj_m4v_dc_chrom : nj_m4v_dc_lum;
                nj_u1 buf[4];
                int   len = (int)tab[i].len;
                int   code = (int)tab[i].code;
                int   j, size;
                nj_u4 pos = 0;

                memset(buf, 0, sizeof(buf));
                for (j = 0; j < len; j++) {
                    if ((code >> (len - 1 - j)) & 1) {
                        buf[j / 8] |= (nj_u1)(0x80u >> (j % 8));
                    }
                }
                size = nj_m4v_decode_dc(buf, (nj_u4)sizeof(buf), &pos, which == 0);
                if (size != i || (int)pos != len) {
                    bad++;
                }
            }
        }
        ok(bad == 0, "every DC size codeword decodes to its own size");
    }

    {
        nj_u1 buf[2];
        nj_u4 pos;
        int   okd = 1;

        /* size 0 reads nothing and means no change */
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 0) == 0 && pos == 0;
        /* Symbol first: a set leading bit means positive.  size 2 reads
         * 10 -> +2, 11 -> +3, 01 -> 1 - 3 = -2, 00 -> 0 - 3 = -3. */
        memset(buf, 0, sizeof(buf));
        buf[0] = 0x80u;                        /* 10xxxxxx */
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 2) == 2 && pos == 2;
        buf[0] = 0x40u;                        /* 01xxxxxx */
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 2) == -2 && pos == 2;
        buf[0] = 0xc0u;                        /* 11xxxxxx */
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 2) == 3 && pos == 2;
        buf[0] = 0x00u;                        /* 00xxxxxx */
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 2) == -3 && pos == 2;
        /* size 1: 1 -> +1, 0 -> -1 */
        buf[0] = 0x80u;
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 1) == 1 && pos == 1;
        buf[0] = 0x00u;
        pos = 0;
        okd &= nj_m4v_dc_delta(buf, 2, &pos, 1) == -1 && pos == 1;
        ok(okd != 0, "DC deltas follow the specification's sign rule");
    }

    {
        int run = -1, level = -9, last = -1, okr = 1;

        okr &= nj_m4v_ac_sym(0, &run, &level, &last) == 1 && run == 0 && level == 1;
        okr &= nj_m4v_ac_sym(NJ_M4V_AC_SYMS, &run, &level, &last) == 0;
        okr &= nj_m4v_ac_sym(1, &run, &level, &last) == 1 &&
               run == (int)nj_m4v_ac_run[1] && level == (int)nj_m4v_ac_level[1] &&
               last == 0;
        okr &= nj_m4v_ac_sym(NJ_M4V_AC_LAST, &run, &level, &last) == 1 && last == 1;
        okr &= nj_m4v_ac_sym(NJ_M4V_AC_LAST - 1, &run, &level, &last) == 1 && last == 0;
        ok(okr != 0, "AC symbols expand to run/level with the reference last flag");
    }

    {
        int seen[64];
        int i, bad = 0;

        memset(seen, 0, sizeof(seen));
        for (i = 0; i < 64; i++) {
            int k = nj_m4v_scan_index(i);

            if (k < 0 || k >= 64 || seen[k] != 0) {
                bad++;
            } else {
                seen[k] = 1;
            }
        }
        ok(bad == 0 && nj_m4v_scan_index(64) == -1,
           "the coefficient scan is a permutation of the 64 positions");
        ok(nj_m4v_scan_index(0) == 0 && nj_m4v_scan_index(1) == 1 &&
           nj_m4v_scan_index(2) == 8 && nj_m4v_scan_index(63) == 63,
           "the scan starts down the first column and ends at the last position");
    }

    {
        nj_s4 coef[64];
        int i, bad = 0;

        for (i = 0; i < 64; i++) {
            coef[i] = 0;
        }
        nj_m4v_coef_store(coef, 0, 7);       /* DC lands at natural 0 */
        nj_m4v_coef_store(coef, 2, -3);      /* scan 2 is natural 8 */
        nj_m4v_coef_store(coef, 63, 5);      /* last scan position, natural 63 */
        nj_m4v_coef_store(coef, 64, 1);      /* out of range: ignored */
        bad += coef[0] != 7 || coef[8] != -3 || coef[63] != 5;
        for (i = 1; i < 64; i++) {
            if (i != 8 && i != 63 && coef[i] != 0) {
                bad++;
            }
        }
        ok(bad == 0, "coefficients land at their natural positions");
    }

    {
        nj_s4 coef[64];
        int i, k = 1, last = -1, rc, run = (int)nj_m4v_ac_run[1];

        for (i = 0; i < 64; i++) {
            coef[i] = 0;
        }
        rc = nj_m4v_coef_apply(coef, &k, 1, &last);
        ok(rc == 0 && k == 1 + run + 1 && last == 0 &&
           coef[nj_m4v_scan_index(1 + run)] == (nj_s4)nj_m4v_ac_level[1],
           "an AC symbol advances the scan cursor and stores its level");
        k = 1;
        ok(nj_m4v_coef_apply(coef, &k, 0, &last) == 0 && k == 2 &&
           coef[nj_m4v_scan_index(1)] == 1,
           "symbol 0 stores run 0 level 1; the escape never reaches this path");
        {
            int sym = -1, j;

            for (j = 1; j < NJ_M4V_AC_SYMS; j++) {
                if (nj_m4v_ac_run[j] > 0) {
                    sym = j;
                    break;
                }
            }
            if (sym > 0) {
                k = 63;
                ok(nj_m4v_coef_apply(coef, &k, sym, &last) == -1,
                   "a run that leaves the block is an error");
            }
        }
    }

    {
        nj_s4 coef[64];
        nj_u1 buf[8];
        nj_u4 pos = 0;
        int i, sym = -1, lastpos;

        for (i = 0; i < 64; i++) coef[i] = 0;
        for (i = 1; i < NJ_M4V_AC_SYMS; i++) {
            if (nj_m4v_ac_run[i] == 0 && i >= NJ_M4V_AC_LAST) { sym = i; break; }
        }
        ok(sym > 0, "a last-flagged zero-run AC symbol exists");
        memset(buf, 0, sizeof(buf));
        for (i = 0; i < 4096; i++) {
            if (nj_m4v_ac_lut[i] != 0xffffu && (int)(nj_m4v_ac_lut[i] & 0xffu) == sym) {
                int len = (int)(nj_m4v_ac_lut[i] >> 8), j;
                for (j = 0; j < len; j++)
                    if ((i >> (NJ_M4V_AC_BITS - 1 - j)) & 1) buf[j / 8] |= (nj_u1)(0x80u >> (j % 8));
                break;
            }
        }
        lastpos = nj_m4v_ac_block(buf, (nj_u4)sizeof(buf), &pos, coef, 1, 4);
        /* The last flag adds 192 to the index, which wraps past coefficient 62
         * and ends the block; a run-0 last symbol lands on coefficient 1. */
        ok(lastpos == 0 && coef[nj_m4v_scan_index(1)] > 0,
           "a block loop stops after the last-flagged symbol");
    }

    {
        nj_u1 buf[8];
        nj_s4 coef[64];
        nj_u4 pos = 0;
        int i, j, sym = -1, bitpos = 0, rc;

        /* DC size 0 (3-bit code 3), then a run-0 last symbol: empty AC. */
        for (i = 1; i < NJ_M4V_AC_SYMS; i++)
            if (nj_m4v_ac_run[i] == 0 && i >= NJ_M4V_AC_LAST) { sym = i; break; }
        memset(buf, 0, sizeof(buf));
        for (j = 0; j < (int)nj_m4v_dc_lum[0].len; j++)
            if ((nj_m4v_dc_lum[0].code >> (nj_m4v_dc_lum[0].len - 1 - (nj_u1)j)) & 1u)
                buf[j / 8] |= (nj_u1)(0x80u >> (j % 8));
        bitpos = (int)nj_m4v_dc_lum[0].len;
        for (i = 0; i < 4096; i++)
            if (nj_m4v_ac_lut[i] != 0xffffu && (int)(nj_m4v_ac_lut[i] & 0xffu) == sym) {
                int len = (int)(nj_m4v_ac_lut[i] >> 8);
                for (j = 0; j < len; j++)
                    if ((i >> (NJ_M4V_AC_BITS - 1 - j)) & 1) buf[(bitpos + j) / 8] |= (nj_u1)(0x80u >> ((bitpos + j) % 8));
                break;
            }
        rc = nj_m4v_decode_intra_block(buf, (nj_u4)sizeof(buf), &pos, coef, 1, 40, 4);
        ok(rc == 0 && coef[0] == 40, "an intra block with an empty AC keeps its predicted DC");
    }

    {
        nj_s4 coef[64];
        int out[64];
        int i, bad = 0;

        for (i = 0; i < 64; i++) coef[i] = 0;
        coef[0] = 64;
        nj_m4v_idct(coef, out);
        for (i = 0; i < 64; i++) if (out[i] != 8) bad++;
        ok(bad == 0, "a DC-only block of 64 transforms to flat 8s");
        coef[0] = 0;
        nj_m4v_idct(coef, out);
        for (i = 0; i < 64; i++) if (out[i] != 0) bad++;
        ok(bad == 0, "an empty block transforms to zeros");
    }

    {
        nj_u1 buf[8], pix[64];
        nj_u4 pos = 0;
        int i, j, sym = -1, bitpos = 0, rc;

        for (i = 1; i < NJ_M4V_AC_SYMS; i++)
            if (nj_m4v_ac_run[i] == 0 && i >= NJ_M4V_AC_LAST) { sym = i; break; }
        memset(buf, 0, sizeof(buf));
        for (j = 0; j < (int)nj_m4v_dc_lum[0].len; j++)
            if ((nj_m4v_dc_lum[0].code >> (nj_m4v_dc_lum[0].len - 1 - (nj_u1)j)) & 1u)
                buf[j / 8] |= (nj_u1)(0x80u >> (j % 8));
        bitpos = (int)nj_m4v_dc_lum[0].len;
        for (i = 0; i < 4096; i++)
            if (nj_m4v_ac_lut[i] != 0xffffu && (int)(nj_m4v_ac_lut[i] & 0xffu) == sym) {
                int len = (int)(nj_m4v_ac_lut[i] >> 8);
                for (j = 0; j < len; j++)
                    if ((i >> (NJ_M4V_AC_BITS - 1 - j)) & 1) buf[(bitpos + j) / 8] |= (nj_u1)(0x80u >> ((bitpos + j) % 8));
                break;
            }
        rc = nj_m4v_decode_intra_pixels(buf, (nj_u4)sizeof(buf), &pos, pix, 1, 0, 4);
        ok(rc == 0 && pix[0] == 128 && pix[63] == 128,
           "a zero-DC block reconstructs to mid-grey");
    }

    {
        nj_u4 mbw = 0, mbh = 0;

        ok(nj_m4v_frame_macroblocks(176u, 144u, &mbw, &mbh) == 0 &&
           mbw == 11u && mbh == 9u, "a 176x144 picture is 11x9 macroblocks");
        ok(nj_m4v_frame_macroblocks(320u, 240u, &mbw, &mbh) == 0 &&
           mbw == 20u && mbh == 15u, "a 320x240 picture is 20x15 macroblocks");
        ok(nj_m4v_frame_macroblocks(17u, 1u, &mbw, &mbh) == 0 &&
           mbw == 2u && mbh == 1u, "a partial macroblock rounds up");
        ok(nj_m4v_frame_macroblocks(0u, 144u, &mbw, &mbh) == -1,
           "a zero width is refused");
    }

    {
        nj_u4 x = 0, y = 0;

        ok(nj_m4v_block_origin(1u, 2u, 0, &x, &y) == 0 && x == 16u && y == 32u,
           "luma block 0 sits at the macroblock origin");
        ok(nj_m4v_block_origin(1u, 2u, 3, &x, &y) == 0 && x == 24u && y == 40u,
           "luma block 3 is the bottom-right 8x8");
        ok(nj_m4v_block_origin(1u, 2u, 4, &x, &y) == 0 && x == 8u && y == 16u,
           "the chroma blocks sit on the half-resolution grid");
        ok(nj_m4v_block_origin(0u, 0u, 6, &x, &y) == -1,
           "there is no seventh block");
    }

    {
        int bad = 0;

        bad += nj_m4v_dc_scale(1, 1) != 8 || nj_m4v_dc_scale(4, 1) != 8;
        bad += nj_m4v_dc_scale(5, 1) != 10 || nj_m4v_dc_scale(31, 1) != 46;
        bad += nj_m4v_dc_scale(5, 0) != 9 || nj_m4v_dc_scale(31, 0) != 25;
        bad += nj_m4v_dc_scale(0, 1) != -1 || nj_m4v_dc_scale(32, 0) != -1;
        ok(bad == 0, "the DC scaler follows the reference table for q 1..31");
    }

    {
        nj_u4 cw = 0, ch = 0;
        int bad = 0;

        bad += nj_m4v_plane_size(176, 144, &cw, &ch) != 0 || cw != 88 || ch != 72;
        bad += nj_m4v_plane_size(320, 240, &cw, &ch) != 0 || cw != 160 || ch != 120;
        bad += nj_m4v_plane_size(177, 145, &cw, &ch) != 0 || cw != 89 || ch != 73;
        bad += nj_m4v_plane_size(0, 144, &cw, &ch) != -1;
        ok(bad == 0, "4:2:0 chroma planes round up and reject empty pictures");
    }

    {
        int bad = 0;

        bad += nj_m4v_dc_predict(6, 8, 8) != 6;
        bad += nj_m4v_dc_predict(6, 8, 16) != 12;
        bad += nj_m4v_dc_predict(-6, 8, 16) != -12;
        bad += nj_m4v_dc_predict(5, 16, 8) != 3;      /* 2.5 rounds to 3 */
        bad += nj_m4v_dc_predict(-5, 16, 8) != -3;
        bad += nj_m4v_dc_predict(1, 0, 8) != -1;
        ok(bad == 0, "neighbour DC scales by the quantiser ratio, rounding away from zero");
    }

    {
        int dir = -1, stored = -1, bad = 0;

        /* left wins when |a-b| >= |b-c| */
        bad += nj_m4v_dc_predict_q(800, 1024, 1024, 8, &dir) != 100 || dir != 0;
        /* top-left wins when the left/top difference is smaller */
        bad += nj_m4v_dc_predict_q(1024, 1024, 800, 8, &dir) != 100 || dir != 1;
        /* a tie goes to the left neighbour, as the reference does */
        bad += nj_m4v_dc_predict_q(1024, 800, 1024, 8, &dir) != 128 || dir != 0;
        /* outside the picture is the neutral 1024 */
        bad += nj_m4v_dc_predict_q(-1, -1, -1, 8, &dir) != 128;
        bad += nj_m4v_dc_level(0, 1024, 8, &stored) != 128 || stored != 1024;
        bad += nj_m4v_dc_level(3, 1024, 8, &stored) != 131 || stored != 1048;
        bad += nj_m4v_dc_level(-200, 1024, 8, &stored) != -72 || stored != 0;
        bad += nj_m4v_dc_level(200, 1024, 8, &stored) != 328 || stored != 2047;
        ok(bad == 0, "DC prediction follows the reference neighbour rule and clamps");
    }

    {
        int a, b, c, bad = 0;

        nj_m4v_dc_avail(0, 0, &a, &b, &c);
        bad += a || b || c;
        nj_m4v_dc_avail(3, 0, &a, &b, &c);
        bad += !a || b || c;
        nj_m4v_dc_avail(0, 5, &a, &b, &c);
        bad += a || !b || c;
        nj_m4v_dc_avail(2, 4, &a, &b, &c);
        bad += !a || !b || !c;
        ok(bad == 0, "DC neighbours follow the picture edges");
    }

    {
        int gx = -1, gy = -1, bad = 0;

        bad += nj_m4v_block_grid(0, 1, 2, &gx, &gy) != 0 || gx != 2 || gy != 4;
        bad += nj_m4v_block_grid(1, 1, 2, &gx, &gy) != 0 || gx != 3 || gy != 4;
        bad += nj_m4v_block_grid(2, 1, 2, &gx, &gy) != 0 || gx != 2 || gy != 5;
        bad += nj_m4v_block_grid(3, 1, 2, &gx, &gy) != 0 || gx != 3 || gy != 5;
        bad += nj_m4v_block_grid(4, 1, 2, &gx, &gy) != 0 || gx != 1 || gy != 2;
        bad += nj_m4v_block_grid(5, 1, 2, &gx, &gy) != 0 || gx != 1 || gy != 2;
        bad += nj_m4v_block_grid(6, 1, 2, &gx, &gy) != -1;
        ok(bad == 0, "each block knows its grid position for DC prediction");
    }

    {
        nj_s2 grid[9];
        int i, bad = 0;

        for (i = 0; i < 9; i++) grid[i] = 0;
        /* first block: no neighbours, neutral 1024, delta 0 */
        bad += nj_m4v_dc_block(grid, 3, 0, 0, 0, 8) != 128 || grid[0] != 1024;
        /* right neighbour predicts from it */
        bad += nj_m4v_dc_block(grid, 3, 1, 0, 0, 8) != 128 || grid[1] != 1024;
        /* delta 3 on the next one */
        bad += nj_m4v_dc_block(grid, 3, 2, 0, 3, 8) != 131 || grid[2] != 1048;
        /* second row predicts from the row above */
        bad += nj_m4v_dc_block(grid, 3, 0, 1, 0, 8) != 128 || grid[3] != 1024;
        bad += nj_m4v_dc_block(NULL, 3, 0, 0, 0, 8) != -1;
        ok(bad == 0, "the DC state machine predicts, adds and stores per block");
    }

    {
        int bad = 0;

        bad += NJ_M4V_MAX_RUN != 20 || NJ_M4V_MAX_LEVEL != 27;
        bad += nj_m4v_max_level_0[0] != 27 || nj_m4v_max_level_1[0] != 8;
        bad += nj_m4v_max_run_0[1] != 14 || nj_m4v_max_run_1[1] != 20;
        ok(bad == 0, "the escape tables match the reference derivation");
    }

    {
        /* bits 0000011 are the escape code word, not symbol 0. */
        const nj_u1 esc[2] = { 0x06u, 0x00u };
        const nj_u1 sym0[2] = { 0x80u, 0x00u };
        nj_u4 pos = 0;
        int last = -1, run = -1, level = -1, rc, bad = 0;

        rc = nj_m4v_decode_ac(esc, 2u, &pos, &last);
        bad += rc != -2 || pos != 7u;
        pos = 0;
        rc = nj_m4v_decode_ac(sym0, 2u, &pos, &last);
        bad += rc != 0 || pos != 2u;
        bad += !nj_m4v_ac_sym(0, &run, &level, &last) || run != 0 || level != 1 || last;
        ok(bad == 0, "the escape is its own code word and symbol 0 is run 0 level 1");
    }

    {
        int bad = 0;

        bad += nj_m4v_qmul(1) != 2 || nj_m4v_qmul(31) != 62;
        bad += nj_m4v_qadd(1) != 1 || nj_m4v_qadd(2) != 1 || nj_m4v_qadd(4) != 3;
        bad += nj_m4v_qmul(0) != 0 || nj_m4v_qmul(32) != 0;
        ok(bad == 0, "the AC scale pair follows qmul = 2q and qadd = (q-1)|1");
    }

    {
        const nj_u1 esc[4] = { 0x07u, 0x80u, 0x80u, 0x2Cu };
        nj_u4 pos = 7u;
        int last = -1, run = -1, level = 0, bad = 0;

        bad += nj_m4v_escape3(esc, 4u, &pos, 2, &last, &run, &level) != 0;
        bad += last != 0 || run != 0 || level != 21;
        pos = 7u;
        bad += nj_m4v_escape3(esc, 3u, &pos, 2, &last, &run, &level) != -1;
        ok(bad == 0, "the third escape form scales its level with qmul and qadd");
    }

    {
        const nj_u1 esc[2] = { 0x06u, 0x80u };
        nj_u4 pos = 7u;
        int last = -1, run = -1, level = 0, bad = 0;

        bad += nj_m4v_escape1(esc, 2u, &pos, 2, &last, &run, &level) != 0;
        bad += last != 0 || run != 0 || level != 1 + 27 * 4;
        ok(bad == 0, "the first escape form adds max_level[last][run] * qmul");
    }

    {
        const nj_u1 esc[2] = { 0x07u, 0x40u };
        nj_u4 pos = 7u;
        int last = -1, run = -1, level = 0, bad = 0;

        bad += nj_m4v_escape2(esc, 2u, &pos, 2, &last, &run, &level) != 0;
        bad += last != 0 || run != 1 || level != 1;
        ok(bad == 0, "the second escape form corrects the run with max_run");
    }

    {
        static nj_u1 yp[4] = { 16u, 235u, 128u, 128u };
        static nj_u1 cp[1] = { 128u };
        nj_u1 out[8];
        nj_u4 o;

        nj_m4v_yuv420_to_rgb565(yp, 2, cp, 1, cp, 1, 2, 2, out);
        o = (nj_u4)out[0] | ((nj_u4)out[1] << 8);
        ok(o == 0x0000u, "Y=16 U=V=128 converts to black");
        o = (nj_u4)out[2] | ((nj_u4)out[3] << 8);
        ok(o == 0xFFFFu, "Y=235 U=V=128 converts to white");
    }

    ok(nj_m4v_dc_coef(2, nj_m4v_dc_scale(1, 1)) == 16 &&
       nj_m4v_dc_coef(2, nj_m4v_dc_scale(5, 1)) == 2 * nj_m4v_dc_scale(5, 1),
       "the DC coefficient is the level times the DC scaler");

    {
        /* Black in MPEG-4 is level 8 at 16x: the reference IDCT writes the
         * dequantised coefficient straight out, so the reconstructed sample is
         * 128/8 = 16.  The block we hand to nj_m4v_idct() is biased by 1024
         * because that IDCT returns a residual that is then offset by 128. */
        nj_s4 coef[64];
        int out[64], i, base;

        for (i = 0; i < 64; i++) coef[i] = 0;
        base = nj_m4v_dc_coef(8, nj_m4v_dc_scale(8, 1)) - NJ_M4V_DC_GREY;
        coef[0] = (nj_s4)base;
        nj_m4v_idct(coef, out);
        ok(base == -896 && out[0] + 128 == 16,
           "level 8 at DC scale 16 reconstructs to the limited-range black sample");

        base = nj_m4v_dc_coef(0, nj_m4v_dc_scale(9, 1)) - NJ_M4V_DC_GREY;
        coef[0] = (nj_s4)base;
        nj_m4v_idct(coef, out);
        ok(out[0] == -128, "level 0 at any scale reconstructs to a black sample");
    }

    {
        /* intra MCBPC symbol 0 is "1", CBPY symbol 15 is "11" */
        static const nj_u1 hdr[1] = { 0xF0u };
        nj_u4 pos = 0;
        int cbp = -1, dq = -1;

        ok(nj_m4v_mb_intra_header(hdr, 8u, &pos, &cbp, &dq) == 0,
           "an intra macroblock header decodes");
        ok(cbp == 60 && dq == 0 && pos == 4u,
           "the header yields cbp 60, no dquant, four bits");
    }

    {
        /* the first video sample of 1942.3gp, byte for byte */
        static const nj_u1 s0[12] = { 0x00,0x00,0x01,0xb6,0x10,0x03,0x09,
                                      0x8c,0x21,0xb6,0xfe,0x36 };
        nj_u4 pos = 56u;                     /* the VOP header ends here */
        int cbp = -1, dq = -1;

        ok(nj_m4v_mb_intra_header(s0, 96u, &pos, &cbp, &dq) == 0,
           "the first real macroblock header decodes");
        ok(cbp == 0 && dq == 0, "it carries no AC blocks");
        ok(pos == 62u, "and consumes its header only");
    }

    {
        /* luminance DC size code 0 is "011"; a block without AC stops there */
        static const nj_u1 b[1] = { 0x80u };
        nj_s4 coef[64];
        nj_u4 pos = 0;
        int i, zero = 1;

        ok(nj_m4v_decode_intra_block_ex(b, 8u, &pos, coef, 1, 0, 2, 0) == 0,
           "a DC-only intra block decodes");
        for (i = 1; i < 64; i++) {
            if (coef[i] != 0) {
                zero = 0;
            }
        }
        ok(zero && pos == 4u, "it carries no AC and consumes four bits");
    }

    ok(nj_m4v_cbp_has_ac(32, 0) == 1 && nj_m4v_cbp_has_ac(16, 1) == 1,
       "cbp bit 5 is the first luma block and bit 4 the second");
    ok(nj_m4v_cbp_has_ac(1, 5) == 1 && nj_m4v_cbp_has_ac(1, 4) == 0,
       "cbp bit 0 belongs to the last chroma block");
    ok(nj_m4v_cbp_has_ac(0x3f, -1) == 0 && nj_m4v_cbp_has_ac(0x3f, 6) == 0,
       "blocks outside 0..5 have no AC bit");

    {
        nj_s2 plane[4 * 4];
        int i;

        for (i = 0; i < 16; i++) {
            plane[i] = (nj_s2)(100 + i);
        }
        ok(nj_m4v_dc_neighbour(plane, 4, 2, 2, 1) == 100 + 1 * 4 + 2,
           "the top neighbour reads the previous row");
        ok(nj_m4v_dc_neighbour(plane, 4, 2, 2, 0) == 100 + 2 * 4 + 1,
           "the left neighbour reads the previous column");
        ok(nj_m4v_dc_neighbour(plane, 4, 0, 3, 0) == 1024,
           "a left neighbour outside the picture reads 1024");
        ok(nj_m4v_dc_neighbour(plane, 4, 3, 0, 2) == 1024,
           "a top-left neighbour outside the picture reads 1024");
    }

    {
        /* A codeword far from the first byte: the bound must be in bits. */
        static nj_u1 wide[64];
        nj_u4 pos = 320;
        int sym = 0, i;

        for (i = 0; i < 64; i++) wide[i] = 0x00;
        wide[320 >> 3] = (nj_u1)0xC0;    /* bits 320..321 = "11" */
        ok(nj_vlc_lookup(wide, (nj_u4)sizeof wide, &pos, nj_vlc_cbpy, 16, &sym) == 0,
           "a codeword at bit 320 is found");
        ok(sym == 15 && pos == 322, "and it is CBPY 15, consuming two bits");
    }

    {
        ok(nj_m4v_scan_index_mode(0, 1) == 0 && nj_m4v_scan_index_mode(9, 1) == 9,
           "the horizontal scan keeps row-major order");
        ok(nj_m4v_scan_index_mode(1, 2) == 8 && nj_m4v_scan_index_mode(8, 2) == 1,
           "the vertical scan transposes row and column");
        ok(nj_m4v_scan_index_mode(63, 0) == nj_m4v_scan_index(63) &&
           nj_m4v_scan_index_mode(-1, 0) == -1 && nj_m4v_scan_index_mode(64, 1) == -1,
           "the default scan is the zigzag, and out-of-range indices are refused");
    }


    /* ---------------- P-VOP building blocks (rounds M1/M2) ------------- */
    {
        /* Every motion-vector VLC symbol round-trips: code word, then a zero
         * sign bit, then the f_code range bits, all decoded against the
         * ff_mvtab table the reference uses. */
        int bad = 0, i;

        for (i = 0; i < 33; i++) {
            nj_u1 buf[4];
            nj_u4 pos = 0;
            int   sym = -1, j, len = nj_vlc_mvtab[i].len;
            int   code = (int)nj_vlc_mvtab[i].code;

            memset(buf, 0, sizeof(buf));
            for (j = 0; j < len; j++) {
                if ((code >> (len - 1 - j)) & 1) {
                    buf[j / 8] |= (nj_u1)(0x80u >> (j % 8));
                }
            }
            if (i == 0) {
                /* symbol 0 is the one-bit "predicted" code word */
                bad += nj_m4v_decode_mv(buf, 4u, &pos, 77, 1) != 77 || pos != 1u;
                continue;
            }
            /* f_code 1: the symbol alone, sign bit 0, predicted value 0.
             * Symbol 32 sits on the sign bit of the 6-bit wrap range, so it
             * decodes to -32 -- exactly what ff_h263_decode_motion does. */
            if (nj_m4v_decode_mv(buf, 4u, &pos, 0, 1) != (i == 32 ? -32 : i) ||
                pos != (nj_u4)len + 1u) {
                bad++;
            }
            /* the same code with the sign bit set decodes to -sym */
            buf[len / 8] |= (nj_u1)(0x80u >> (len % 8));
            pos = 0;
            if (nj_m4v_decode_mv(buf, 4u, &pos, 0, 1) != ((i == 32) ? -32 : -i)) {
                bad++;
            }
            (void)sym;
        }
        ok(bad == 0, "every motion-vector code round-trips through nj_m4v_decode_mv");
    }
    {
        /* f_code range bits: symbol 1 with f_code 2 and extra bit 1 is +2;
         * symbol 2 with extra 0 is +3; and the predictor is wrapped into the
         * 5+f_code-bit signed range (ituh263dec.c ff_h263_decode_motion). */
        nj_u1 buf[4];
        nj_u4 pos;
        int bad = 0;

        /* symbol 1 ("01"), sign 0, extra bit 1 -> 2 at f_code 2 */
        memset(buf, 0, sizeof(buf));
        buf[0] = 0x50u;                 /* 0101 0000 */
        pos = 0;
        bad += nj_m4v_decode_mv(buf, 4u, &pos, 0, 2) != 2 || pos != 4u;

        /* symbol 2 ("001"), sign 0, extra bit 0 -> 3 at f_code 2 */
        buf[0] = 0x20u;                 /* 0010 0000 */
        pos = 0;
        bad += nj_m4v_decode_mv(buf, 4u, &pos, 0, 2) != 3 || pos != 5u;

        /* symbol 5 ("0000101"), sign 0: 5 + 30 wraps to -29 at f_code 1 */
        buf[0] = 0x0Au;                 /* 0000 1010 */
        pos = 0;
        bad += nj_m4v_decode_mv(buf, 4u, &pos, 30, 1) != -29;
        /* f_code 3 adds two range bits: symbol 5 becomes ((5-1)<<2)+1 = 17,
         * and 17 + 30 = 47 with no wrap in the 8-bit range */
        pos = 0;
        bad += nj_m4v_decode_mv(buf, 4u, &pos, 30, 3) != 47;
        ok(bad == 0, "f_code range bits and the modulo wrap follow the reference");
    }
    {
        /* Motion-vector prediction.  A 2x2 macroblock grid: wrap 5, pad 7, so
         * block (0,0) starts at index 7 and every 8x8 slot carries its own
         * index as MV (border entries are zero).  The reference medians are
         * mid(left, top, top-right) with the first-row special cases. */
        nj_s2 mvx[32], mvy[32];
        int i, bad = 0, px = 0, py = 0;
        int wrap = 5, pad = 7;

        for (i = 0; i < 32; i++) {
            mvx[i] = 0;
            mvy[i] = 0;
        }
        /* valid slots: row0: 7,8 (mb0), 9,10 (mb1); row1: 12,13, 14,15;
         * row2: 17,18, 19,20; row3: 22,23, 24,25 */
        for (i = 0; i < 4; i++) {
            mvx[7 + i] = (nj_s2)(7 + i);
            mvx[12 + i] = (nj_s2)(12 + i);
            mvx[17 + i] = (nj_s2)(17 + i);
            mvx[22 + i] = (nj_s2)(22 + i);
            mvy[7 + i] = (nj_s2)(-(7 + i));
            mvy[12 + i] = (nj_s2)(-(12 + i));
            mvy[17 + i] = (nj_s2)(-(17 + i));
            mvy[22 + i] = (nj_s2)(-(22 + i));
        }
        /* MB(1,1) is not on the first slice line: block 0 medians
         * (A=18, B=14, C=0) = 14; block 1 (A=19, B=15, C=0) = 15;
         * block 2 (A=23, B=19, C=20) = 20; block 3 (A=24, B=20, C=19) = 20. */
        nj_m4v_pred_motion(mvx, mvy, wrap, pad, 1, 1, 0, 0, 0, &px, &py);
        bad += px != 14 || py != -14;
        nj_m4v_pred_motion(mvx, mvy, wrap, pad, 1, 1, 1, 0, 0, &px, &py);
        bad += px != 15 || py != -15;
        nj_m4v_pred_motion(mvx, mvy, wrap, pad, 1, 1, 2, 0, 0, &px, &py);
        bad += px != 20 || py != -20;
        nj_m4v_pred_motion(mvx, mvy, wrap, pad, 1, 1, 3, 0, 0, &px, &py);
        bad += px != 20 || py != -20;
        /* MB(0,0) on the first slice line predicts 0 for block 0. */
        nj_m4v_pred_motion(mvx, mvy, wrap, pad, 0, 0, 0, 1, 0, &px, &py);
        bad += px != 0 || py != 0;
        /* Block 2 on that line still uses the real neighbours:
         * (A=13, B=9, C=10) = 10. */
        nj_m4v_pred_motion(mvx, mvy, wrap, pad, 1, 0, 2, 1, 0, &px, &py);
        bad += px != 10 || py != -10;
        ok(bad == 0, "the 8x8 motion-vector predictor follows ff_h263_pred_motion");
    }
    {
        /* Half-pel motion compensation: a 16x16 ramp.  Integer vectors move
         * whole samples, half-pel vectors average, and the no-rounding variant
         * of vop_rounding_type truncates.  Edge reads replicate the edge. */
        nj_u1 src[16 * 16], out[64];
        int i, j, bad = 0;

        for (j = 0; j < 16; j++) {
            for (i = 0; i < 16; i++) {
                src[j * 16 + i] = (nj_u1)(j * 16 + i);
            }
        }
        /* mv (0,0): straight copy of the top-left 8x8 */
        nj_m4v_mc_block8(0, 0, 0, 0, src, 16, 16, 16, 0, 0, out);
        for (j = 0; j < 8; j++) {
            for (i = 0; i < 8; i++) {
                if (out[j * 8 + i] != src[j * 16 + i]) {
                    bad++;
                }
            }
        }
        /* mv (2,0) is one integer luma sample to the right */
        nj_m4v_mc_block8(0, 0, 2, 0, src, 16, 16, 16, 0, 0, out);
        for (j = 0; j < 8; j++) {
            for (i = 0; i < 8; i++) {
                if (out[j * 8 + i] != src[j * 16 + i + 1]) {
                    bad++;
                }
            }
        }
        /* mv (1,0): horizontal half-pel, rounded up */
        nj_m4v_mc_block8(0, 0, 1, 0, src, 16, 16, 16, 0, 0, out);
        for (j = 0; j < 2; j++) {
            for (i = 0; i < 8; i++) {
                int want = (src[j * 16 + i] + src[j * 16 + i + 1] + 1) >> 1;

                if (out[j * 8 + i] != want) {
                    bad++;
                }
            }
        }
        /* mv (0,1) with no_rounding is a half-pel vertical read that
         * truncates: (a+c)>>1 -- the reference's no-rounding op. */
        nj_m4v_mc_block8(2, 2, 0, 1, src, 16, 16, 16, 0, 1, out);
        for (j = 0; j < 2; j++) {
            for (i = 0; i < 2; i++) {
                int a = src[(2 + j) * 16 + 2 + i];
                int c = src[(3 + j) * 16 + 2 + i];
                int want = (a + c) >> 1;

                if (out[j * 8 + i] != want) {
                    bad++;
                }
            }
        }
        /* mv (3,3): both halves rounded, (a+b+c+d+2)>>2 */
        nj_m4v_mc_block8(4, 4, 3, 3, src, 16, 16, 16, 0, 0, out);
        {
            int a = src[5 * 16 + 5], b = src[5 * 16 + 6];
            int c = src[6 * 16 + 5], d = src[6 * 16 + 6];
            int want = (a + b + c + d + 2) >> 2;

            bad += out[0] != want;
        }
        /* chroma shift=1: mv 2 means integer 0 and a half-pel flag */
        nj_m4v_mc_block8(0, 0, 2, 2, src, 16, 16, 16, 1, 0, out);
        {
            int a = src[0], b = src[1], c = src[16], d = src[17];
            int want = (a + b + c + d + 2) >> 2;

            bad += out[0] != want;
        }
        /* reading left of the frame replicates the first column */
        nj_m4v_mc_block8(-4, 0, 0, 0, src, 16, 16, 16, 0, 0, out);
        bad += out[0] != src[0] || out[8] != src[16];
        ok(bad == 0, "half-pel motion compensation matches the reference kernel");
    }
    {
        /* ff_h263_round_chroma: one half-pel chroma vector from the sum of
         * four luma vectors, with the reference's rounding table. */
        int bad = 0;

        bad += nj_m4v_chroma_round(0) != 0;
        bad += nj_m4v_chroma_round(3) != 1;
        bad += nj_m4v_chroma_round(4) != 1;
        bad += nj_m4v_chroma_round(8) != 1;
        bad += nj_m4v_chroma_round(11) != 1;
        bad += nj_m4v_chroma_round(14) != 2;
        bad += nj_m4v_chroma_round(-1) != 0;
        bad += nj_m4v_chroma_round(-8) != -1;
        ok(bad == 0, "the 4MV chroma vector uses ff_h263_round_chroma");
    }
    {
        /* The exact Simple IDCT: values pinned from FFmpeg's own
         * ff_simple_idct_put_int16_8bit / ff_simple_idct_add_int16_8bit, so a
         * change in rounding fails here instead of only in whole-frame diffs. */
        nj_s4 coef[64];
        int   out[64];
        int   i, bad = 0;

        for (i = 0; i < 64; i++) {
            coef[i] = 0;
        }
        /* put: mid-grey plus a few AC terms (ffmpeg: put block A) */
        coef[0] = 1024;
        coef[8] = 100;
        coef[16] = -50;
        coef[1] = 30;
        nj_m4v_idct_put(coef, out);
        {
            static const int want_first[8] = { 142, 142, 140, 138, 136, 134, 133, 132 };
            static const int want_last[8]  = { 108, 107, 105, 104, 101, 100, 98, 97 };

            for (i = 0; i < 8; i++) {
                if (out[i] != want_first[i]) bad++;
                if (out[56 + i] != want_last[i]) bad++;
            }
        }
        /* put: DC 128 is the limited-range black sample 16 (mid-grey bias) */
        for (i = 0; i < 64; i++) {
            coef[i] = 0;
        }
        coef[0] = 128;
        nj_m4v_idct_put(coef, out);
        for (i = 0; i < 64; i++) {
            if (out[i] != 16) bad++;
        }
        /* add: the inter residual of the same block is flat per row */
        for (i = 0; i < 64; i++) {
            coef[i] = 0;
        }
        coef[0] = 23;
        coef[8] = -39;
        coef[16] = 23;
        coef[32] = -23;
        coef[40] = 23;
        nj_m4v_idct(coef, out);
        {
            static const int row0[8] = { -1, -1, -1, -1, -1, -1, -1, -1 };
            static const int row4[8] = { -6, -6, -6, -6, -6, -6, -6, -6 };
            static const int row6[8] = { 17, 17, 17, 17, 17, 17, 17, 17 };

            for (i = 0; i < 8; i++) {
                if (out[i] != row0[i]) bad++;
                if (out[32 + i] != row4[i]) bad++;
                if (out[48 + i] != row6[i]) bad++;
            }
        }
        ok(bad == 0, "the Simple IDCT matches ffmpeg's put/add rounding exactly");
    }
    {
        /* The first P-VOP of 1942.3gp carries vop_rounding_type 1 (the
         * reference prints it as "rnd:0" because it logs 1-no_rounding). */
        static const nj_u1 vop_p[] = {
            0x00, 0x00, 0x01, 0xb6, 0x50, 0xa3, 0x82, 0x1f, 0xfe, 0xb7
        };
        nj_m4v_vop vop;
        nj_u4 end = 32u;

        ok(nj_m4v_parse_vop_bits(vop_p, (nj_u4)sizeof(vop_p), &end, 1000u, &vop) == 1 &&
           vop.no_rounding == 1 && end == 60u,
           "the P-VOP rounding type reaches the macroblock layer's MC choice");
    }


    {
        /* End-to-end P-VOP gate on the corpus's own bytes: decode samples 0..3
         * of 1942.3gp (I, P, I, P) in sequence and check the reference planes.
         * A regression anywhere in motion compensation, the motion-vector
         * predictor, the rounding type or the IDCT changes samples and breaks
         * the hashes; this runs without files or a container parser. */
        static const nj_u1 *const sv[4] = {
            m4v_sample_0, m4v_sample_1, m4v_sample_2, m4v_sample_3
        };
        static nj_u1 cur_y[176 * 144], cur_u[88 * 72], cur_v[88 * 72];
        static nj_u1 pre_y[176 * 144], pre_u[88 * 72], pre_v[88 * 72];
        nj_s4 grids[300];
        nj_m4v_vol vol;
        int bad = 0, bad_bits = 0, bad_hash = 0, bad_row = 0, f;

        memset(grids, 0, sizeof(grids));
        memset(pre_y, 0, sizeof(pre_y));
        memset(pre_u, 0, sizeof(pre_u));
        memset(pre_v, 0, sizeof(pre_v));
        if (parse_cfg(cfg_1942, (nj_u4)sizeof(cfg_1942), &vol) != 1) {
            bad++;
        }
        for (f = 0; f < 4; f++) {
            nj_m4v_vop vop;
            nj_u4 pos = 0, bitpos, n = m4v_sample_sizes[f];
            int rc;

            if (nj_m4v_find_vop(sv[f], n, &pos) != 1) {
                bad++;
                break;
            }
            bitpos = pos * 8u;
            if (nj_m4v_parse_vop_bits_vol(sv[f], n, &bitpos, &vol, &vop) != 1) {
                bad++;
                break;
            }
            if (vop.type != (f % 2 == 0 ? 0 : 1)) {
                bad++;
            }
            if (vop.type == 0) {
                rc = nj_m4v_decode_ivop(sv[f], n, &bitpos, &vol, &vop, grids,
                                        cur_y, 176, cur_u, 88, cur_v, 88);
            } else {
                rc = nj_m4v_decode_pvop(sv[f], n, &bitpos, &vol, &vop, grids,
                                        cur_y, 176, cur_u, 88, cur_v, 88,
                                        pre_y, 176, pre_u, 88, pre_v, 88);
            }
            bad += rc != 0;
            /* a VOP ends with at most the trailing zero padding */
            bad_bits += bitpos + 16u < n * 8u;
            if (f == 1 || f == 3) {
                int k = (f == 1) ? 0 : 1;

                bad_hash += fnv1a(cur_y, 176u * 144u) != m4v_ref_hash[k][0];
                bad_hash += fnv1a(cur_u, 88u * 72u) != m4v_ref_hash[k][1];
                bad_hash += fnv1a(cur_v, 88u * 72u) != m4v_ref_hash[k][2];
                {
                    const nj_u1 *row = (f == 1) ? m4v_ref_row_1 : m4v_ref_row_3;
                    int off = (f == 1) ? 56 * 176 + 120 : 64 * 176 + 120, i;

                    for (i = 0; i < 8; i++) {
                        bad_row += cur_y[off + i] != row[i];
                    }
                }
            }
            memcpy(pre_y, cur_y, sizeof(pre_y));
            memcpy(pre_u, cur_u, sizeof(pre_u));
            memcpy(pre_v, cur_v, sizeof(pre_v));
        }
        ok(bad == 0 && bad_bits == 0,
           "the I/P/I/P chain of 1942.3gp consumes every sample");
        ok(bad_hash == 0,
           "its second and fourth frames reproduce the reference planes exactly");
        ok(bad_row == 0, "reference pixels at named coordinates match too");
    }


    {
        /* The nj_avcodec provider: open the real mp4v fixture, decode every
         * frame and compare the RGB565 output with the pinned reference
         * hashes.  This is the seam createPlayer() and the Player pump use. */
        static unsigned long live;
        nj_av_mem mem;
        nj_av_info info;
        const char *err = NULL;
        const nj_av_video_ops *ops = nj_avcodec_sw_m4v();
        nj_av_dec *dec;
        static nj_u1 out[M4V_CLIP_WIDTH * M4V_CLIP_HEIGHT * 2];
        static const nj_u1 junk[10] = { 0, 1, 2, 3, 4, 5, 6, 7, 8, 9 };
        int f, bad = 0, end = 0;

        mem.ud = NULL;
        mem.alloc = m4v_test_alloc;
        mem.free = m4v_test_free;
        live = 0;

        ok(ops != NULL, "the software MPEG-4 Part 2 provider exists");
        if (ops == NULL) {
            goto provider_done;
        }
        ok(ops->accepts(m4v_clip_3gp, (nj_u4)sizeof(m4v_clip_3gp)) == 1 &&
           ops->accepts(junk, (nj_u4)sizeof(junk)) == 0 &&
           ops->accepts(m4v_clip_avc1, (nj_u4)sizeof(m4v_clip_avc1)) == 0,
           "the provider accepts mp4v containers and claims nothing else");
        memset(&info, 0, sizeof(info));
        dec = ops->open(m4v_clip_3gp, (nj_u4)sizeof(m4v_clip_3gp), &mem, &info,
                        &err);
        ok(dec != NULL && info.format == NJ_AV_VIDEO_MPEG4 &&
           info.width == M4V_CLIP_WIDTH && info.height == M4V_CLIP_HEIGHT &&
           info.frames == M4V_CLIP_FRAMES && info.pixfmt == NJ_AV_PIX_RGB565 &&
           info.fps == 10u,
           "the provider opens the fixture and reports its geometry");
        if (dec == NULL) {
            goto provider_done;
        }
        for (f = 0; f < M4V_CLIP_FRAMES; f++) {
            nj_av_step step;

            memset(&step, 0, sizeof(step));
            step.out = out;
            step.out_cap = (nj_u4)sizeof(out);
            if (ops->decode(dec, &step) != NJ_AV_OK || step.frames != 1u ||
                step.out_used != (nj_u4)sizeof(out) ||
                fnv1a(out, (nj_u4)sizeof(out)) != m4v_clip_rgb_hash[f]) {
                bad++;
            }
        }
        {
            nj_av_step step;

            memset(&step, 0, sizeof(step));
            step.out = out;
            step.out_cap = (nj_u4)sizeof(out);
            end = ops->decode(dec, &step) == NJ_AV_ERR_END;
        }
        ops->close(dec);
        ok(bad == 0, "the provider decodes every frame to the reference pixels");
        ok(end != 0, "the provider reports the end of the sample table");
provider_done:
        ok(live == 0, "the provider releases everything it allocated");
        err = NULL;
        dec = (ops != NULL)
            ? ops->open(m4v_clip_avc1, (nj_u4)sizeof(m4v_clip_avc1), &mem,
                        &info, &err)
            : NULL;
        ok(dec == NULL && err != NULL, "an avc1 container is refused by name");
    }

    printf("test_m4v: %d checks, %d failure(s)\n", checks, fails);
    return fails == 0 ? 0 : 1;
}
