/* Regression fixture, compiled with javac --release 8 -g:none.
 * Class version lowered to CLDC 48; no Java 8 features are used.
 * Reproduce from this source:
 * package resolve;
 * interface Root { int value(); }
 * interface Left extends Root {}
 * interface Right extends Root {}
 * interface Leaf extends Left, Right {}
 * class Impl implements Leaf {
 *     public int value() { return 42; }
 *     public int hashCode() { return 17; }
 *     public String toString() { return "resolved"; }
 * }
 * public class Probe {
 *     static int throughLeaf(Leaf x) { return x.value(); }
 *     public static int inherited() {
 *         Leaf x = new Impl();
 *         return throughLeaf(x) + throughLeaf(x);
 *     }
 *     public static int objectMethods() {
 *         Leaf x = new Impl();
 *         return x.getClass() != null && x.hashCode() == 17 &&
 *                x.equals(x) && "resolved".equals(x.toString()) ? 1 : 0;
 *     }
 *     public static int nullReceiver() {
 *         try { return throughLeaf(null); }
 *         catch (NullPointerException ex) { return 1; }
 *     }
 * }
 */
#include "nj2me/nj.h"
#include "nj_internal.h"
#include <stdio.h>
static const nj_u1 Root_class[] = {
    0xca, 0xfe, 0xba, 0xbe, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x07, 0x00, 0x02, 0x01, 0x00, 0x0c,
    0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f, 0x52, 0x6f, 0x6f, 0x74, 0x07, 0x00, 0x04, 0x01,
    0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a, 0x65,
    0x63, 0x74, 0x01, 0x00, 0x05, 0x76, 0x61, 0x6c, 0x75, 0x65, 0x01, 0x00, 0x03, 0x28, 0x29, 0x49,
    0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x04, 0x01, 0x00, 0x05,
    0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
};
static const nj_u1 Left_class[] = {
    0xca, 0xfe, 0xba, 0xbe, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x07, 0x00, 0x02, 0x01, 0x00, 0x0c,
    0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f, 0x4c, 0x65, 0x66, 0x74, 0x07, 0x00, 0x04, 0x01,
    0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a, 0x65,
    0x63, 0x74, 0x07, 0x00, 0x06, 0x01, 0x00, 0x0c, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f,
    0x52, 0x6f, 0x6f, 0x74, 0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x01, 0x00, 0x05, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00,
};
static const nj_u1 Right_class[] = {
    0xca, 0xfe, 0xba, 0xbe, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x07, 0x00, 0x02, 0x01, 0x00, 0x0d,
    0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f, 0x52, 0x69, 0x67, 0x68, 0x74, 0x07, 0x00, 0x04,
    0x01, 0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a,
    0x65, 0x63, 0x74, 0x07, 0x00, 0x06, 0x01, 0x00, 0x0c, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65,
    0x2f, 0x52, 0x6f, 0x6f, 0x74, 0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x01, 0x00, 0x05, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00,
};
static const nj_u1 Leaf_class[] = {
    0xca, 0xfe, 0xba, 0xbe, 0x00, 0x00, 0x00, 0x30, 0x00, 0x09, 0x07, 0x00, 0x02, 0x01, 0x00, 0x0c,
    0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f, 0x4c, 0x65, 0x61, 0x66, 0x07, 0x00, 0x04, 0x01,
    0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a, 0x65,
    0x63, 0x74, 0x07, 0x00, 0x06, 0x01, 0x00, 0x0c, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f,
    0x4c, 0x65, 0x66, 0x74, 0x07, 0x00, 0x08, 0x01, 0x00, 0x0d, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76,
    0x65, 0x2f, 0x52, 0x69, 0x67, 0x68, 0x74, 0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
    0x05, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static const nj_u1 Impl_class[] = {
    0xca, 0xfe, 0xba, 0xbe, 0x00, 0x00, 0x00, 0x30, 0x00, 0x13, 0x0a, 0x00, 0x02, 0x00, 0x03, 0x07,
    0x00, 0x04, 0x0c, 0x00, 0x05, 0x00, 0x06, 0x01, 0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c,
    0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a, 0x65, 0x63, 0x74, 0x01, 0x00, 0x06, 0x3c, 0x69, 0x6e,
    0x69, 0x74, 0x3e, 0x01, 0x00, 0x03, 0x28, 0x29, 0x56, 0x08, 0x00, 0x08, 0x01, 0x00, 0x08, 0x72,
    0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x64, 0x07, 0x00, 0x0a, 0x01, 0x00, 0x0c, 0x72, 0x65, 0x73,
    0x6f, 0x6c, 0x76, 0x65, 0x2f, 0x49, 0x6d, 0x70, 0x6c, 0x07, 0x00, 0x0c, 0x01, 0x00, 0x0c, 0x72,
    0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65, 0x2f, 0x4c, 0x65, 0x61, 0x66, 0x01, 0x00, 0x04, 0x43, 0x6f,
    0x64, 0x65, 0x01, 0x00, 0x05, 0x76, 0x61, 0x6c, 0x75, 0x65, 0x01, 0x00, 0x03, 0x28, 0x29, 0x49,
    0x01, 0x00, 0x08, 0x68, 0x61, 0x73, 0x68, 0x43, 0x6f, 0x64, 0x65, 0x01, 0x00, 0x08, 0x74, 0x6f,
    0x53, 0x74, 0x72, 0x69, 0x6e, 0x67, 0x01, 0x00, 0x14, 0x28, 0x29, 0x4c, 0x6a, 0x61, 0x76, 0x61,
    0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x53, 0x74, 0x72, 0x69, 0x6e, 0x67, 0x3b, 0x00, 0x20, 0x00,
    0x09, 0x00, 0x02, 0x00, 0x01, 0x00, 0x0b, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x05, 0x00,
    0x06, 0x00, 0x01, 0x00, 0x0d, 0x00, 0x00, 0x00, 0x11, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00,
    0x05, 0x2a, 0xb7, 0x00, 0x01, 0xb1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0e, 0x00, 0x0f,
    0x00, 0x01, 0x00, 0x0d, 0x00, 0x00, 0x00, 0x0f, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
    0x10, 0x2a, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x0f, 0x00, 0x01, 0x00,
    0x0d, 0x00, 0x00, 0x00, 0x0f, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x10, 0x11, 0xac,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x11, 0x00, 0x12, 0x00, 0x01, 0x00, 0x0d, 0x00, 0x00,
    0x00, 0x0f, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x12, 0x07, 0xb0, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00,
};
static const nj_u1 Probe_class[] = {
    0xca, 0xfe, 0xba, 0xbe, 0x00, 0x00, 0x00, 0x30, 0x00, 0x31, 0x0a, 0x00, 0x02, 0x00, 0x03, 0x07,
    0x00, 0x04, 0x0c, 0x00, 0x05, 0x00, 0x06, 0x01, 0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c,
    0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a, 0x65, 0x63, 0x74, 0x01, 0x00, 0x06, 0x3c, 0x69, 0x6e,
    0x69, 0x74, 0x3e, 0x01, 0x00, 0x03, 0x28, 0x29, 0x56, 0x0b, 0x00, 0x08, 0x00, 0x09, 0x07, 0x00,
    0x0a, 0x0c, 0x00, 0x0b, 0x00, 0x0c, 0x01, 0x00, 0x0c, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65,
    0x2f, 0x4c, 0x65, 0x61, 0x66, 0x01, 0x00, 0x05, 0x76, 0x61, 0x6c, 0x75, 0x65, 0x01, 0x00, 0x03,
    0x28, 0x29, 0x49, 0x07, 0x00, 0x0e, 0x01, 0x00, 0x0c, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76, 0x65,
    0x2f, 0x49, 0x6d, 0x70, 0x6c, 0x0a, 0x00, 0x0d, 0x00, 0x03, 0x0a, 0x00, 0x11, 0x00, 0x12, 0x07,
    0x00, 0x13, 0x0c, 0x00, 0x14, 0x00, 0x15, 0x01, 0x00, 0x0d, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76,
    0x65, 0x2f, 0x50, 0x72, 0x6f, 0x62, 0x65, 0x01, 0x00, 0x0b, 0x74, 0x68, 0x72, 0x6f, 0x75, 0x67,
    0x68, 0x4c, 0x65, 0x61, 0x66, 0x01, 0x00, 0x11, 0x28, 0x4c, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76,
    0x65, 0x2f, 0x4c, 0x65, 0x61, 0x66, 0x3b, 0x29, 0x49, 0x0b, 0x00, 0x08, 0x00, 0x17, 0x0c, 0x00,
    0x18, 0x00, 0x19, 0x01, 0x00, 0x08, 0x67, 0x65, 0x74, 0x43, 0x6c, 0x61, 0x73, 0x73, 0x01, 0x00,
    0x13, 0x28, 0x29, 0x4c, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x43, 0x6c,
    0x61, 0x73, 0x73, 0x3b, 0x0b, 0x00, 0x08, 0x00, 0x1b, 0x0c, 0x00, 0x1c, 0x00, 0x0c, 0x01, 0x00,
    0x08, 0x68, 0x61, 0x73, 0x68, 0x43, 0x6f, 0x64, 0x65, 0x0b, 0x00, 0x08, 0x00, 0x1e, 0x0c, 0x00,
    0x1f, 0x00, 0x20, 0x01, 0x00, 0x06, 0x65, 0x71, 0x75, 0x61, 0x6c, 0x73, 0x01, 0x00, 0x15, 0x28,
    0x4c, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x4f, 0x62, 0x6a, 0x65, 0x63,
    0x74, 0x3b, 0x29, 0x5a, 0x08, 0x00, 0x22, 0x01, 0x00, 0x08, 0x72, 0x65, 0x73, 0x6f, 0x6c, 0x76,
    0x65, 0x64, 0x0b, 0x00, 0x08, 0x00, 0x24, 0x0c, 0x00, 0x25, 0x00, 0x26, 0x01, 0x00, 0x08, 0x74,
    0x6f, 0x53, 0x74, 0x72, 0x69, 0x6e, 0x67, 0x01, 0x00, 0x14, 0x28, 0x29, 0x4c, 0x6a, 0x61, 0x76,
    0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x53, 0x74, 0x72, 0x69, 0x6e, 0x67, 0x3b, 0x0a, 0x00,
    0x28, 0x00, 0x1e, 0x07, 0x00, 0x29, 0x01, 0x00, 0x10, 0x6a, 0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61,
    0x6e, 0x67, 0x2f, 0x53, 0x74, 0x72, 0x69, 0x6e, 0x67, 0x07, 0x00, 0x2b, 0x01, 0x00, 0x1e, 0x6a,
    0x61, 0x76, 0x61, 0x2f, 0x6c, 0x61, 0x6e, 0x67, 0x2f, 0x4e, 0x75, 0x6c, 0x6c, 0x50, 0x6f, 0x69,
    0x6e, 0x74, 0x65, 0x72, 0x45, 0x78, 0x63, 0x65, 0x70, 0x74, 0x69, 0x6f, 0x6e, 0x01, 0x00, 0x04,
    0x43, 0x6f, 0x64, 0x65, 0x01, 0x00, 0x09, 0x69, 0x6e, 0x68, 0x65, 0x72, 0x69, 0x74, 0x65, 0x64,
    0x01, 0x00, 0x0d, 0x6f, 0x62, 0x6a, 0x65, 0x63, 0x74, 0x4d, 0x65, 0x74, 0x68, 0x6f, 0x64, 0x73,
    0x01, 0x00, 0x0d, 0x53, 0x74, 0x61, 0x63, 0x6b, 0x4d, 0x61, 0x70, 0x54, 0x61, 0x62, 0x6c, 0x65,
    0x01, 0x00, 0x0c, 0x6e, 0x75, 0x6c, 0x6c, 0x52, 0x65, 0x63, 0x65, 0x69, 0x76, 0x65, 0x72, 0x00,
    0x21, 0x00, 0x11, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0x00, 0x01, 0x00, 0x05, 0x00,
    0x06, 0x00, 0x01, 0x00, 0x2c, 0x00, 0x00, 0x00, 0x11, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00,
    0x05, 0x2a, 0xb7, 0x00, 0x01, 0xb1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x14, 0x00, 0x15,
    0x00, 0x01, 0x00, 0x2c, 0x00, 0x00, 0x00, 0x13, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
    0x2a, 0xb9, 0x00, 0x07, 0x01, 0x00, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x09, 0x00, 0x2d, 0x00,
    0x0c, 0x00, 0x01, 0x00, 0x2c, 0x00, 0x00, 0x00, 0x1e, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00,
    0x12, 0xbb, 0x00, 0x0d, 0x59, 0xb7, 0x00, 0x0f, 0x4b, 0x2a, 0xb8, 0x00, 0x10, 0x2a, 0xb8, 0x00,
    0x10, 0x60, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x09, 0x00, 0x2e, 0x00, 0x0c, 0x00, 0x01, 0x00,
    0x2c, 0x00, 0x00, 0x00, 0x56, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3a, 0xbb, 0x00, 0x0d,
    0x59, 0xb7, 0x00, 0x0f, 0x4b, 0x2a, 0xb9, 0x00, 0x16, 0x01, 0x00, 0xc6, 0x00, 0x2a, 0x2a, 0xb9,
    0x00, 0x1a, 0x01, 0x00, 0x10, 0x11, 0xa0, 0x00, 0x1f, 0x2a, 0x2a, 0xb9, 0x00, 0x1d, 0x02, 0x00,
    0x99, 0x00, 0x15, 0x12, 0x21, 0x2a, 0xb9, 0x00, 0x23, 0x01, 0x00, 0xb6, 0x00, 0x27, 0x99, 0x00,
    0x07, 0x04, 0xa7, 0x00, 0x04, 0x03, 0xac, 0x00, 0x00, 0x00, 0x01, 0x00, 0x2f, 0x00, 0x00, 0x00,
    0x0a, 0x00, 0x02, 0xfc, 0x00, 0x38, 0x07, 0x00, 0x08, 0x40, 0x01, 0x00, 0x09, 0x00, 0x30, 0x00,
    0x0c, 0x00, 0x01, 0x00, 0x2c, 0x00, 0x00, 0x00, 0x28, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00,
    0x08, 0x01, 0xb8, 0x00, 0x10, 0xac, 0x4b, 0x04, 0xac, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
    0x05, 0x00, 0x2a, 0x00, 0x01, 0x00, 0x2f, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0x45, 0x07, 0x00,
    0x2a, 0x00, 0x00,
};

/* Probe's #7 is resolve/Leaf.value:()I.  A fresh VM keeps each mutation
 * independent of the successful resolution cached by the execution tests. */
static int test_rejected_inheritance(const nj_port *port, unsigned variant)
{
    nj_vm *vm = nj_vm_create(port, 2u * 1024u * 1024u);
    nj_class *root, *probe;
    nj_cpentry *entry;
    int failed = 0;
    const char *label = variant == 0 ? "static" :
                        variant == 1 ? "private" : "wrong descriptor";
    if (!vm) return 1;
    root = nj_class_load(vm, "resolve/Root", Root_class, sizeof(Root_class));
    if (!root ||
        !nj_class_load(vm, "resolve/Left", Left_class, sizeof(Left_class)) ||
        !nj_class_load(vm, "resolve/Right", Right_class, sizeof(Right_class)) ||
        !nj_class_load(vm, "resolve/Leaf", Leaf_class, sizeof(Leaf_class)) ||
        !(probe = nj_class_load(vm, "resolve/Probe", Probe_class, sizeof(Probe_class)))) {
        nj_vm_destroy(vm);
        return 1;
    }
    if (variant == 0) root->methods[0].flags |= NJ_ACC_STATIC;
    else if (variant == 1) root->methods[0].flags = NJ_ACC_PRIVATE | NJ_ACC_ABSTRACT;
    else root->methods[0].desc = "(I)I";
    if (nj_cp_resolve(vm, probe, 7u, &entry) == NJ_OK ||
        vm->resolve_fail != NJ_RESOLVE_METHOD) {
        fprintf(stderr, "FAIL inherited %s method was not rejected\n", label);
        failed = 1;
    } else {
        printf("PASS reject inherited %s\n", label);
    }
    nj_vm_destroy(vm);
    return failed;
}

int main(void)
{
    nj_port port;
    nj_vm *vm;
    nj_value ret;
    int failed = 0;
    unsigned i;
    static const struct { const char *name; nj_s4 expected; } cases[] = {
        { "inherited", 84 }, { "objectMethods", 1 }, { "nullReceiver", 1 }
    };
    if (nj_port_headless(&port) != NJ_OK) return 2;
    vm = nj_vm_create(&port, 2u * 1024u * 1024u);
    if (!vm) { nj_port_shutdown(&port); return 2; }
#define LOAD(name) do { \
    if (!nj_class_load(vm, "resolve/" #name, name##_class, sizeof(name##_class))) { \
        fprintf(stderr, "failed to load " #name "\n"); failed++; \
    } \
} while (0)
    LOAD(Root); LOAD(Left); LOAD(Right); LOAD(Leaf); LOAD(Impl); LOAD(Probe);
#undef LOAD
    for (i = 0; i < sizeof(cases) / sizeof(cases[0]); i++) {
        ret.bits = 0;
        if (nj_call_static(vm, "resolve/Probe", cases[i].name, "()I", NULL, &ret) != NJ_OK) {
            fprintf(stderr, "FAIL %s: %s\n", cases[i].name, nj_exception_describe(vm));
            failed++;
            nj_clear_exception(vm);
        } else if (ret.i != cases[i].expected) {
            fprintf(stderr, "FAIL %s: got %ld, expected %ld\n", cases[i].name,
                    (long)ret.i, (long)cases[i].expected);
            failed++;
        } else {
            printf("PASS %s\n", cases[i].name);
        }
    }
    nj_vm_destroy(vm);
    for (i = 0; i < 3; i++) failed += test_rejected_inheritance(&port, i);
    nj_port_shutdown(&port);
    return failed ? 1 : 0;
}
