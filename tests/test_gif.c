/*
 * nano_j2me - tests/test_gif.c
 *
 * The built-in GIF decoder.
 *
 * MIDP 1.0 required GIF and MIDP 2.0 kept it, but a MIDlet that cannot decode
 * its own artwork usually swallows the IOException and carries on painting a
 * null Image - which reads as a black screen rather than as an error.  That is
 * exactly how the missing decoder showed up, so this test pins the contract:
 *
 *   - a GIF87a, a GIF89a with a transparent index and an interlaced GIF all
 *     decode to the pixels the file describes (interlacing is the case where
 *     a row-mapping mistake turns the picture into a scrambled one, so every
 *     row of that fixture is checked);
 *   - only the FIRST frame of an animated GIF is used;
 *   - the transparent index becomes alpha=0, everything else alpha=0xFF;
 *   - the provider claims only what it can read: accepts() answers for
 *     GIF87a/GIF89a and refuses anything else, including a PNG;
 *   - malformed input (empty, truncated, corrupted) returns NULL with a
 *     message, never a half-built image, and never crashes;
 *   - every block the decoder takes through its hooks is handed back, so a
 *     failed decode does not leak.
 *
 * Usage: test_gif
 */
#include "nj2me/nj.h"

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

static int checks;
static int failures;

#define CHECK(cond, what)                                                    \
    do {                                                                     \
        checks++;                                                            \
        if (!(cond)) {                                                       \
            failures++;                                                      \
            printf("  FAIL %s:%d  %s\n", __FILE__, __LINE__, (what));        \
        }                                                                    \
    } while (0)

#define CHECK_EQ(a, b, what)                                                 \
    do {                                                                     \
        long va_ = (long)(a);                                                \
        long vb_ = (long)(b);                                                \
        checks++;                                                            \
        if (va_ != vb_) {                                                    \
            failures++;                                                      \
            printf("  FAIL %s:%d  %s (%ld != %ld)\n",                        \
                   __FILE__, __LINE__, (what), va_, vb_);                    \
        }                                                                    \
    } while (0)

/* ------------------------------------------------------------------ */
/* A counting allocator, so a decode that forgets to free is visible    */
/* ------------------------------------------------------------------ */
static int live_blocks;

static void *count_alloc(void *ud, nj_size n)
{
    void *p;
    (void)ud;
    p = malloc((size_t)n);
    if (p) {
        live_blocks++;
    }
    return p;
}

static void count_free(void *ud, void *p)
{
    (void)ud;
    if (p) {
        live_blocks--;
    }
    free(p);
}

/* The decoder allocates the pixel buffer and the nj_image through the hooks,
 * so releasing means giving both back to the same allocator. */
static void release_image(nj_image *img)
{
    if (!img) {
        return;
    }
    count_free(NULL, img->pixels);
    count_free(NULL, img);
}

/* ------------------------------------------------------------------ */
/* Fixtures: real GIFs, generated once and embedded so the test needs   */
/* neither PIL nor a data directory.                                    */
/* ------------------------------------------------------------------ */
static const unsigned char k_gif87[] = {
    0x47u, 0x49u, 0x46u, 0x38u, 0x37u, 0x61u, 0x04u, 0x00u, 0x03u, 0x00u, 0x81u, 0x00u,
    0x00u, 0xFFu, 0x00u, 0x00u, 0x00u, 0xFFu, 0x00u, 0x00u, 0x00u, 0xFFu, 0xFFu, 0xFFu,
    0xFFu, 0x2Cu, 0x00u, 0x00u, 0x00u, 0x00u, 0x04u, 0x00u, 0x03u, 0x00u, 0x00u, 0x08u,
    0x0Du, 0x00u, 0x01u, 0x04u, 0x10u, 0x30u, 0x60u, 0xE0u, 0x00u, 0x00u, 0x04u, 0x05u,
    0x06u, 0x04u, 0x00u, 0x3Bu,
};

static const unsigned char k_gif89_transparent[] = {
    0x47u, 0x49u, 0x46u, 0x38u, 0x39u, 0x61u, 0x04u, 0x00u, 0x03u, 0x00u, 0x81u, 0x00u,
    0x00u, 0xFFu, 0x00u, 0x00u, 0x00u, 0xFFu, 0x00u, 0x00u, 0x00u, 0xFFu, 0xFFu, 0xFFu,
    0xFFu, 0x21u, 0xF9u, 0x04u, 0x01u, 0x00u, 0x00u, 0x03u, 0x00u, 0x2Cu, 0x00u, 0x00u,
    0x00u, 0x00u, 0x04u, 0x00u, 0x03u, 0x00u, 0x00u, 0x08u, 0x0Eu, 0x00u, 0x07u, 0x04u,
    0x10u, 0x00u, 0x60u, 0x00u, 0xC1u, 0x00u, 0x03u, 0x00u, 0x0Cu, 0x0Cu, 0x08u, 0x00u,
    0x3Bu,
};

static const unsigned char k_gif_interlaced[] = {
    0x47u, 0x49u, 0x46u, 0x38u, 0x37u, 0x61u, 0x10u, 0x00u, 0x10u, 0x00u, 0x87u, 0x00u,
    0x00u, 0x00u, 0xFFu, 0x00u, 0x01u, 0xFEu, 0x03u, 0x02u, 0xFDu, 0x06u, 0x03u, 0xFCu,
    0x09u, 0x04u, 0xFBu, 0x0Cu, 0x05u, 0xFAu, 0x0Fu, 0x06u, 0xF9u, 0x12u, 0x07u, 0xF8u,
    0x15u, 0x08u, 0xF7u, 0x18u, 0x09u, 0xF6u, 0x1Bu, 0x0Au, 0xF5u, 0x1Eu, 0x0Bu, 0xF4u,
    0x21u, 0x0Cu, 0xF3u, 0x24u, 0x0Du, 0xF2u, 0x27u, 0x0Eu, 0xF1u, 0x2Au, 0x0Fu, 0xF0u,
    0x2Du, 0x10u, 0xEFu, 0x30u, 0x11u, 0xEEu, 0x33u, 0x12u, 0xEDu, 0x36u, 0x13u, 0xECu,
    0x39u, 0x14u, 0xEBu, 0x3Cu, 0x15u, 0xEAu, 0x3Fu, 0x16u, 0xE9u, 0x42u, 0x17u, 0xE8u,
    0x45u, 0x18u, 0xE7u, 0x48u, 0x19u, 0xE6u, 0x4Bu, 0x1Au, 0xE5u, 0x4Eu, 0x1Bu, 0xE4u,
    0x51u, 0x1Cu, 0xE3u, 0x54u, 0x1Du, 0xE2u, 0x57u, 0x1Eu, 0xE1u, 0x5Au, 0x1Fu, 0xE0u,
    0x5Du, 0x20u, 0xDFu, 0x60u, 0x21u, 0xDEu, 0x63u, 0x22u, 0xDDu, 0x66u, 0x23u, 0xDCu,
    0x69u, 0x24u, 0xDBu, 0x6Cu, 0x25u, 0xDAu, 0x6Fu, 0x26u, 0xD9u, 0x72u, 0x27u, 0xD8u,
    0x75u, 0x28u, 0xD7u, 0x78u, 0x29u, 0xD6u, 0x7Bu, 0x2Au, 0xD5u, 0x7Eu, 0x2Bu, 0xD4u,
    0x81u, 0x2Cu, 0xD3u, 0x84u, 0x2Du, 0xD2u, 0x87u, 0x2Eu, 0xD1u, 0x8Au, 0x2Fu, 0xD0u,
    0x8Du, 0x30u, 0xCFu, 0x90u, 0x31u, 0xCEu, 0x93u, 0x32u, 0xCDu, 0x96u, 0x33u, 0xCCu,
    0x99u, 0x34u, 0xCBu, 0x9Cu, 0x35u, 0xCAu, 0x9Fu, 0x36u, 0xC9u, 0xA2u, 0x37u, 0xC8u,
    0xA5u, 0x38u, 0xC7u, 0xA8u, 0x39u, 0xC6u, 0xABu, 0x3Au, 0xC5u, 0xAEu, 0x3Bu, 0xC4u,
    0xB1u, 0x3Cu, 0xC3u, 0xB4u, 0x3Du, 0xC2u, 0xB7u, 0x3Eu, 0xC1u, 0xBAu, 0x3Fu, 0xC0u,
    0xBDu, 0x40u, 0xBFu, 0xC0u, 0x41u, 0xBEu, 0xC3u, 0x42u, 0xBDu, 0xC6u, 0x43u, 0xBCu,
    0xC9u, 0x44u, 0xBBu, 0xCCu, 0x45u, 0xBAu, 0xCFu, 0x46u, 0xB9u, 0xD2u, 0x47u, 0xB8u,
    0xD5u, 0x48u, 0xB7u, 0xD8u, 0x49u, 0xB6u, 0xDBu, 0x4Au, 0xB5u, 0xDEu, 0x4Bu, 0xB4u,
    0xE1u, 0x4Cu, 0xB3u, 0xE4u, 0x4Du, 0xB2u, 0xE7u, 0x4Eu, 0xB1u, 0xEAu, 0x4Fu, 0xB0u,
    0xEDu, 0x50u, 0xAFu, 0xF0u, 0x51u, 0xAEu, 0xF3u, 0x52u, 0xADu, 0xF6u, 0x53u, 0xACu,
    0xF9u, 0x54u, 0xABu, 0xFCu, 0x55u, 0xAAu, 0xFFu, 0x56u, 0xA9u, 0x02u, 0x57u, 0xA8u,
    0x05u, 0x58u, 0xA7u, 0x08u, 0x59u, 0xA6u, 0x0Bu, 0x5Au, 0xA5u, 0x0Eu, 0x5Bu, 0xA4u,
    0x11u, 0x5Cu, 0xA3u, 0x14u, 0x5Du, 0xA2u, 0x17u, 0x5Eu, 0xA1u, 0x1Au, 0x5Fu, 0xA0u,
    0x1Du, 0x60u, 0x9Fu, 0x20u, 0x61u, 0x9Eu, 0x23u, 0x62u, 0x9Du, 0x26u, 0x63u, 0x9Cu,
    0x29u, 0x64u, 0x9Bu, 0x2Cu, 0x65u, 0x9Au, 0x2Fu, 0x66u, 0x99u, 0x32u, 0x67u, 0x98u,
    0x35u, 0x68u, 0x97u, 0x38u, 0x69u, 0x96u, 0x3Bu, 0x6Au, 0x95u, 0x3Eu, 0x6Bu, 0x94u,
    0x41u, 0x6Cu, 0x93u, 0x44u, 0x6Du, 0x92u, 0x47u, 0x6Eu, 0x91u, 0x4Au, 0x6Fu, 0x90u,
    0x4Du, 0x70u, 0x8Fu, 0x50u, 0x71u, 0x8Eu, 0x53u, 0x72u, 0x8Du, 0x56u, 0x73u, 0x8Cu,
    0x59u, 0x74u, 0x8Bu, 0x5Cu, 0x75u, 0x8Au, 0x5Fu, 0x76u, 0x89u, 0x62u, 0x77u, 0x88u,
    0x65u, 0x78u, 0x87u, 0x68u, 0x79u, 0x86u, 0x6Bu, 0x7Au, 0x85u, 0x6Eu, 0x7Bu, 0x84u,
    0x71u, 0x7Cu, 0x83u, 0x74u, 0x7Du, 0x82u, 0x77u, 0x7Eu, 0x81u, 0x7Au, 0x7Fu, 0x80u,
    0x7Du, 0x80u, 0x7Fu, 0x80u, 0x81u, 0x7Eu, 0x83u, 0x82u, 0x7Du, 0x86u, 0x83u, 0x7Cu,
    0x89u, 0x84u, 0x7Bu, 0x8Cu, 0x85u, 0x7Au, 0x8Fu, 0x86u, 0x79u, 0x92u, 0x87u, 0x78u,
    0x95u, 0x88u, 0x77u, 0x98u, 0x89u, 0x76u, 0x9Bu, 0x8Au, 0x75u, 0x9Eu, 0x8Bu, 0x74u,
    0xA1u, 0x8Cu, 0x73u, 0xA4u, 0x8Du, 0x72u, 0xA7u, 0x8Eu, 0x71u, 0xAAu, 0x8Fu, 0x70u,
    0xADu, 0x90u, 0x6Fu, 0xB0u, 0x91u, 0x6Eu, 0xB3u, 0x92u, 0x6Du, 0xB6u, 0x93u, 0x6Cu,
    0xB9u, 0x94u, 0x6Bu, 0xBCu, 0x95u, 0x6Au, 0xBFu, 0x96u, 0x69u, 0xC2u, 0x97u, 0x68u,
    0xC5u, 0x98u, 0x67u, 0xC8u, 0x99u, 0x66u, 0xCBu, 0x9Au, 0x65u, 0xCEu, 0x9Bu, 0x64u,
    0xD1u, 0x9Cu, 0x63u, 0xD4u, 0x9Du, 0x62u, 0xD7u, 0x9Eu, 0x61u, 0xDAu, 0x9Fu, 0x60u,
    0xDDu, 0xA0u, 0x5Fu, 0xE0u, 0xA1u, 0x5Eu, 0xE3u, 0xA2u, 0x5Du, 0xE6u, 0xA3u, 0x5Cu,
    0xE9u, 0xA4u, 0x5Bu, 0xECu, 0xA5u, 0x5Au, 0xEFu, 0xA6u, 0x59u, 0xF2u, 0xA7u, 0x58u,
    0xF5u, 0xA8u, 0x57u, 0xF8u, 0xA9u, 0x56u, 0xFBu, 0xAAu, 0x55u, 0xFEu, 0xABu, 0x54u,
    0x01u, 0xACu, 0x53u, 0x04u, 0xADu, 0x52u, 0x07u, 0xAEu, 0x51u, 0x0Au, 0xAFu, 0x50u,
    0x0Du, 0xB0u, 0x4Fu, 0x10u, 0xB1u, 0x4Eu, 0x13u, 0xB2u, 0x4Du, 0x16u, 0xB3u, 0x4Cu,
    0x19u, 0xB4u, 0x4Bu, 0x1Cu, 0xB5u, 0x4Au, 0x1Fu, 0xB6u, 0x49u, 0x22u, 0xB7u, 0x48u,
    0x25u, 0xB8u, 0x47u, 0x28u, 0xB9u, 0x46u, 0x2Bu, 0xBAu, 0x45u, 0x2Eu, 0xBBu, 0x44u,
    0x31u, 0xBCu, 0x43u, 0x34u, 0xBDu, 0x42u, 0x37u, 0xBEu, 0x41u, 0x3Au, 0xBFu, 0x40u,
    0x3Du, 0xC0u, 0x3Fu, 0x40u, 0xC1u, 0x3Eu, 0x43u, 0xC2u, 0x3Du, 0x46u, 0xC3u, 0x3Cu,
    0x49u, 0xC4u, 0x3Bu, 0x4Cu, 0xC5u, 0x3Au, 0x4Fu, 0xC6u, 0x39u, 0x52u, 0xC7u, 0x38u,
    0x55u, 0xC8u, 0x37u, 0x58u, 0xC9u, 0x36u, 0x5Bu, 0xCAu, 0x35u, 0x5Eu, 0xCBu, 0x34u,
    0x61u, 0xCCu, 0x33u, 0x64u, 0xCDu, 0x32u, 0x67u, 0xCEu, 0x31u, 0x6Au, 0xCFu, 0x30u,
    0x6Du, 0xD0u, 0x2Fu, 0x70u, 0xD1u, 0x2Eu, 0x73u, 0xD2u, 0x2Du, 0x76u, 0xD3u, 0x2Cu,
    0x79u, 0xD4u, 0x2Bu, 0x7Cu, 0xD5u, 0x2Au, 0x7Fu, 0xD6u, 0x29u, 0x82u, 0xD7u, 0x28u,
    0x85u, 0xD8u, 0x27u, 0x88u, 0xD9u, 0x26u, 0x8Bu, 0xDAu, 0x25u, 0x8Eu, 0xDBu, 0x24u,
    0x91u, 0xDCu, 0x23u, 0x94u, 0xDDu, 0x22u, 0x97u, 0xDEu, 0x21u, 0x9Au, 0xDFu, 0x20u,
    0x9Du, 0xE0u, 0x1Fu, 0xA0u, 0xE1u, 0x1Eu, 0xA3u, 0xE2u, 0x1Du, 0xA6u, 0xE3u, 0x1Cu,
    0xA9u, 0xE4u, 0x1Bu, 0xACu, 0xE5u, 0x1Au, 0xAFu, 0xE6u, 0x19u, 0xB2u, 0xE7u, 0x18u,
    0xB5u, 0xE8u, 0x17u, 0xB8u, 0xE9u, 0x16u, 0xBBu, 0xEAu, 0x15u, 0xBEu, 0xEBu, 0x14u,
    0xC1u, 0xECu, 0x13u, 0xC4u, 0xEDu, 0x12u, 0xC7u, 0xEEu, 0x11u, 0xCAu, 0xEFu, 0x10u,
    0xCDu, 0xF0u, 0x0Fu, 0xD0u, 0xF1u, 0x0Eu, 0xD3u, 0xF2u, 0x0Du, 0xD6u, 0xF3u, 0x0Cu,
    0xD9u, 0xF4u, 0x0Bu, 0xDCu, 0xF5u, 0x0Au, 0xDFu, 0xF6u, 0x09u, 0xE2u, 0xF7u, 0x08u,
    0xE5u, 0xF8u, 0x07u, 0xE8u, 0xF9u, 0x06u, 0xEBu, 0xFAu, 0x05u, 0xEEu, 0xFBu, 0x04u,
    0xF1u, 0xFCu, 0x03u, 0xF4u, 0xFDu, 0x02u, 0xF7u, 0xFEu, 0x01u, 0xFAu, 0xFFu, 0x00u,
    0xFDu, 0x2Cu, 0x00u, 0x00u, 0x00u, 0x00u, 0x10u, 0x00u, 0x10u, 0x00u, 0x40u, 0x08u,
    0xFFu, 0x00u, 0x01u, 0x04u, 0x10u, 0x30u, 0x80u, 0x40u, 0x01u, 0x03u, 0x07u, 0x10u,
    0x24u, 0x50u, 0xB0u, 0x80u, 0x41u, 0x03u, 0x07u, 0x0Fu, 0x00u, 0x05u, 0x12u, 0x34u,
    0x88u, 0x50u, 0x21u, 0x43u, 0x87u, 0x10u, 0x25u, 0x52u, 0xB4u, 0x88u, 0x51u, 0x23u,
    0x47u, 0x8Fu, 0x80u, 0x04u, 0x11u, 0x32u, 0x84u, 0x48u, 0x11u, 0x23u, 0x47u, 0x90u,
    0x24u, 0x51u, 0xB2u, 0x84u, 0x49u, 0x13u, 0x27u, 0x4Fu, 0x80u, 0x05u, 0x13u, 0x36u,
    0x8Cu, 0x58u, 0x31u, 0x63u, 0xC7u, 0x90u, 0x25u, 0x53u, 0xB6u, 0x8Cu, 0x59u, 0x33u,
    0x67u, 0xCFu, 0x40u, 0x84u, 0x10u, 0x31u, 0x82u, 0x44u, 0x09u, 0x13u, 0x27u, 0x50u,
    0xA4u, 0x50u, 0xB1u, 0x82u, 0x45u, 0x0Bu, 0x17u, 0x2Fu, 0xC0u, 0x84u, 0x11u, 0x33u,
    0x86u, 0x4Cu, 0x19u, 0x33u, 0x67u, 0xD0u, 0xA4u, 0x51u, 0xB3u, 0x86u, 0x4Du, 0x1Bu,
    0x37u, 0x6Fu, 0x40u, 0x85u, 0x12u, 0x35u, 0x8Au, 0x54u, 0x29u, 0x53u, 0xA7u, 0x50u,
    0xA5u, 0x52u, 0xB5u, 0x8Au, 0x55u, 0x2Bu, 0x57u, 0xAFu, 0xC0u, 0x85u, 0x13u, 0x37u,
    0x8Eu, 0x5Cu, 0x39u, 0x73u, 0xE7u, 0xD0u, 0xA5u, 0x53u, 0xB7u, 0x8Eu, 0x5Du, 0x3Bu,
    0x77u, 0xEFu, 0x20u, 0x44u, 0x90u, 0x30u, 0x81u, 0x42u, 0x05u, 0x0Bu, 0x17u, 0x30u,
    0x64u, 0xD0u, 0xB0u, 0x81u, 0x43u, 0x07u, 0x0Fu, 0x1Fu, 0x60u, 0xC4u, 0x90u, 0x31u,
    0x83u, 0x46u, 0x0Du, 0x1Bu, 0x37u, 0x70u, 0xE4u, 0xD0u, 0xB1u, 0x83u, 0x47u, 0x0Fu,
    0x1Fu, 0x3Fu, 0xA0u, 0x44u, 0x91u, 0x32u, 0x85u, 0x4Au, 0x15u, 0x2Bu, 0x57u, 0xB0u,
    0x64u, 0xD1u, 0xB2u, 0x85u, 0x4Bu, 0x17u, 0x2Fu, 0x5Fu, 0xE0u, 0xC4u, 0x91u, 0x33u,
    0x87u, 0x4Eu, 0x1Du, 0x3Bu, 0x77u, 0xF0u, 0xE4u, 0xD1u, 0xB3u, 0x87u, 0x4Fu, 0x1Fu,
    0x3Fu, 0x7Fu, 0x20u, 0x45u, 0x92u, 0x34u, 0x89u, 0x52u, 0x25u, 0x4Bu, 0x97u, 0x30u,
    0x65u, 0xD2u, 0xB4u, 0x89u, 0x53u, 0x27u, 0x4Fu, 0x9Fu, 0x60u, 0xC5u, 0x92u, 0x35u,
    0x8Bu, 0x56u, 0x2Du, 0x5Bu, 0xB7u, 0x70u, 0xE5u, 0xD2u, 0xB5u, 0x8Bu, 0x57u, 0x2Fu,
    0x5Fu, 0xBFu, 0xA0u, 0x45u, 0x24u, 0x93u, 0x36u, 0x8Du, 0x5Au, 0x35u, 0x6Bu, 0xD7u,
    0xB0u, 0x65u, 0xD3u, 0xB6u, 0x8Du, 0x5Bu, 0x37u, 0x6Fu, 0xDFu, 0xE0u, 0xC5u, 0x93u,
    0x37u, 0x8Fu, 0x5Eu, 0x3Du, 0x7Bu, 0xF7u, 0xF0u, 0xE5u, 0xD3u, 0xB7u, 0x8Fu, 0x5Fu,
    0x3Fu, 0x7Fu, 0xFFu, 0x04u, 0x04u, 0x00u, 0x3Bu,
};

static const unsigned char k_gif_animated[] = {
    0x47u, 0x49u, 0x46u, 0x38u, 0x39u, 0x61u, 0x08u, 0x00u, 0x08u, 0x00u, 0x81u, 0x00u,
    0x00u, 0x00u, 0xFFu, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u,
    0x00u, 0x21u, 0xFFu, 0x0Bu, 0x4Eu, 0x45u, 0x54u, 0x53u, 0x43u, 0x41u, 0x50u, 0x45u,
    0x32u, 0x2Eu, 0x30u, 0x03u, 0x01u, 0x00u, 0x00u, 0x00u, 0x21u, 0xF9u, 0x04u, 0x00u,
    0x0Au, 0x00u, 0x00u, 0x00u, 0x2Cu, 0x00u, 0x00u, 0x00u, 0x00u, 0x08u, 0x00u, 0x08u,
    0x00u, 0x00u, 0x08u, 0x0Fu, 0x00u, 0x01u, 0x08u, 0x1Cu, 0x48u, 0xB0u, 0xA0u, 0xC1u,
    0x83u, 0x08u, 0x13u, 0x2Au, 0x4Cu, 0x18u, 0x10u, 0x00u, 0x21u, 0xF9u, 0x04u, 0x01u,
    0x0Au, 0x00u, 0x01u, 0x00u, 0x2Cu, 0x00u, 0x00u, 0x00u, 0x00u, 0x08u, 0x00u, 0x08u,
    0x00u, 0x81u, 0x00u, 0x00u, 0xFFu, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u,
    0x00u, 0x00u, 0x08u, 0x0Fu, 0x00u, 0x01u, 0x08u, 0x1Cu, 0x48u, 0xB0u, 0xA0u, 0xC1u,
    0x83u, 0x08u, 0x13u, 0x2Au, 0x4Cu, 0x18u, 0x10u, 0x00u, 0x3Bu,
};

static unsigned pixel_at(const nj_image *img, int x, int y)
{
    return img->pixels[(nj_size)y * (nj_size)img->width + (nj_size)x];
}

static unsigned rgb_at(const nj_image *img, int x, int y)
{
    return pixel_at(img, x, y) & 0x00FFFFFFu;
}

static unsigned alpha_at(const nj_image *img, int x, int y)
{
    return (pixel_at(img, x, y) >> 24) & 0xFFu;
}

/* The palette the four-entry fixtures use. */
static const unsigned k_pal4[4] = { 0xFF0000u, 0x00FF00u, 0x0000FFu, 0xFFFFFFu };

/* ------------------------------------------------------------------ */
/* 1. A plain GIF87a, every pixel                                      */
/* ------------------------------------------------------------------ */
static void test_plain(void)
{
    const char *err = "untouched";
    nj_image *img = nj_gif_decode(k_gif87, (nj_u4)sizeof(k_gif87),
                                  count_alloc, NULL, count_free, &err);
    int x;
    int y;

    CHECK(img != NULL, "a GIF87a decodes");
    if (!img) {
        printf("  (error: %s)\n", err ? err : "?");
        return;
    }
    CHECK_EQ(img->width, 4, "width comes from the logical screen");
    CHECK_EQ(img->height, 3, "height comes from the logical screen");
    CHECK_EQ(img->format, NJ_PIXFMT_ARGB8888,
             "a GIF decodes to ARGB8888, so transparency survives");
    CHECK(img->has_alpha, "and the image says so");
    for (y = 0; y < 3; y++) {
        for (x = 0; x < 4; x++) {
            unsigned want = k_pal4[(x + y) % 4];
            CHECK_EQ(rgb_at(img, x, y), want, "palette index maps to its colour");
            CHECK_EQ(alpha_at(img, x, y), 0xFFu, "an opaque pixel is opaque");
        }
    }
    release_image(img);
    CHECK_EQ(live_blocks, 0, "a successful decode releases everything it took");
}

/* ------------------------------------------------------------------ */
/* 2. Transparency is alpha, not a colour                              */
/* ------------------------------------------------------------------ */
static void test_transparent(void)
{
    nj_image *img = nj_gif_decode(k_gif89_transparent,
                                  (nj_u4)sizeof(k_gif89_transparent),
                                  count_alloc, NULL, count_free, NULL);
    int y;

    CHECK(img != NULL, "a GIF89a with a transparent index decodes");
    if (!img) {
        return;
    }
    for (y = 0; y < 3; y++) {
        CHECK_EQ(alpha_at(img, 0, y), 0u, "the transparent index is alpha 0");
        CHECK_EQ(pixel_at(img, 0, y), 0u, "and carries no colour");
        CHECK_EQ(alpha_at(img, 1, y), 0xFFu, "the next column is opaque");
    }
    CHECK_EQ(rgb_at(img, 1, 0), k_pal4[1], "the colours around it are right");
    release_image(img);
    CHECK_EQ(live_blocks, 0, "a transparent decode releases everything");
}

/* ------------------------------------------------------------------ */
/* 3. Interlacing: every row must land on its real row                 */
/* ------------------------------------------------------------------ */
/* The fixture's palette entry v is (v, 255-v, 3v), and pixel (x,y) is
 * index y*16+x - so a permuted row is immediately visible. */
static void test_interlaced(void)
{
    nj_image *img = nj_gif_decode(k_gif_interlaced,
                                  (nj_u4)sizeof(k_gif_interlaced),
                                  count_alloc, NULL, count_free, NULL);
    int y;

    CHECK(img != NULL, "an interlaced GIF decodes");
    if (!img) {
        return;
    }
    CHECK_EQ(img->width, 16, "interlaced width");
    CHECK_EQ(img->height, 16, "interlaced height");
    for (y = 0; y < 16; y++) {
        unsigned idx = (unsigned)(y * 16);
        unsigned want = ((idx & 0xFFu) << 16) |
                        (((255u - idx) & 0xFFu) << 8) |
                        ((idx * 3u) & 0xFFu);
        int x;
        CHECK_EQ(rgb_at(img, 0, y), want, "interlaced row lands where it belongs");
        for (x = 1; x < 16; x++) {
            unsigned j = idx + (unsigned)x;
            unsigned want2 = ((j & 0xFFu) << 16) |
                             (((255u - j) & 0xFFu) << 8) |
                             ((j * 3u) & 0xFFu);
            if (rgb_at(img, x, y) != want2) {
                break;
            }
        }
        CHECK_EQ(x, 16, "every pixel of the row is in place");
    }
    release_image(img);
    CHECK_EQ(live_blocks, 0, "an interlaced decode releases everything");
}

/* ------------------------------------------------------------------ */
/* 4. An animated GIF contributes its first frame                      */
/* ------------------------------------------------------------------ */
static void test_animated(void)
{
    nj_image *img = nj_gif_decode(k_gif_animated,
                                  (nj_u4)sizeof(k_gif_animated),
                                  count_alloc, NULL, count_free, NULL);
    int i;

    CHECK(img != NULL, "an animated GIF decodes");
    if (!img) {
        return;
    }
    CHECK_EQ(img->width, 8, "animated width");
    CHECK_EQ(img->height, 8, "animated height");
    for (i = 0; i < 64; i++) {
        if (rgb_at(img, i % 8, i / 8) != k_pal4[1]) {
            break;
        }
    }
    CHECK_EQ(i, 64, "only the first frame is drawn, not the second");
    release_image(img);
}

/* ------------------------------------------------------------------ */
/* 5. The provider claims exactly GIF                                  */
/* ------------------------------------------------------------------ */
static void test_provider(void)
{
    nj_image_info info;

    CHECK(nj_codec_gif_software.name != NULL, "the provider is named");
    CHECK((nj_codec_gif_software.caps.formats & NJ_CODEC_FMT_GIF) != 0u,
          "the provider advertises GIF");
    CHECK(nj_codec_gif_software.accepts(k_gif87, (nj_u4)sizeof(k_gif87)) != 0,
          "accepts() takes a GIF87a");
    CHECK(nj_codec_gif_software.accepts(k_gif89_transparent,
                                        (nj_u4)sizeof(k_gif89_transparent)) != 0,
          "accepts() takes a GIF89a");
    CHECK(nj_codec_gif_software.accepts("GIF8", 4u) == 0,
          "a truncated signature is not a GIF");
    CHECK(nj_gif_decode("GIF89a", 6u, count_alloc, NULL, count_free, NULL) == NULL,
          "a bare signature with no header is not a decodable image");

    memset(&info, 0, sizeof(info));
    CHECK_EQ(nj_codec_gif_software.info(k_gif87, (nj_u4)sizeof(k_gif87), &info),
             NJ_OK, "info() reads the header without decoding");
    CHECK_EQ(info.width, 4, "info() width");
    CHECK_EQ(info.height, 3, "info() height");
    CHECK_EQ(info.format, NJ_CODEC_FMT_GIF, "info() reports the format");
}

/* ------------------------------------------------------------------ */
/* 6. Malformed input: no crash, no half-built image, no leak          */
/* ------------------------------------------------------------------ */
static void test_malformed(void)
{
    static const unsigned char not_a_gif[] = { 'P', 'N', 'G', 0x0Du, 0x0Au };
    const char *err;
    nj_image *img;
    nj_u4 cut;

    err = "untouched";
    img = nj_gif_decode(not_a_gif, (nj_u4)sizeof(not_a_gif),
                        count_alloc, NULL, count_free, &err);
    CHECK(img == NULL, "a PNG is refused, not mis-parsed");
    CHECK(err != NULL && strcmp(err, "untouched") != 0,
          "and the refusal explains itself");

    CHECK(nj_gif_decode(k_gif87, 0u, count_alloc, NULL, count_free, &err) == NULL,
          "an empty buffer is refused");
    CHECK(nj_gif_decode(NULL, 0u, count_alloc, NULL, count_free, &err) == NULL,
          "a NULL buffer is refused");

    /* Every truncation of both fixtures, including inside the LZW stream. */
    for (cut = 0u; cut < (nj_u4)sizeof(k_gif87); cut++) {
        img = nj_gif_decode(k_gif87, cut, count_alloc, NULL, count_free, &err);
        if (img) {
            CHECK_EQ(img->width, 4, "a truncation that decodes is still well formed");
            CHECK_EQ(img->height, 3, "a truncation that decodes is still well formed");
            release_image(img);
        } else if (cut < 13u) {
            CHECK(err != NULL, "a truncated header is refused with a message");
        }
    }
    for (cut = 0u; cut < (nj_u4)sizeof(k_gif_interlaced); cut++) {
        img = nj_gif_decode(k_gif_interlaced, cut, count_alloc, NULL, count_free, &err);
        if (img) {
            CHECK_EQ(img->width, 16, "a truncated interlaced GIF is well formed");
            release_image(img);
        }
    }

    /* One corrupted byte at a time: never a crash, never a bad image. */
    {
        unsigned char buf[sizeof(k_gif_interlaced)];
        nj_u4 i;
        for (i = 13u; i < (nj_u4)sizeof(k_gif_interlaced); i++) {
            memcpy(buf, k_gif_interlaced, sizeof(buf));
            buf[i] = (unsigned char)(buf[i] ^ 0x5Au);
            img = nj_gif_decode(buf, (nj_u4)sizeof(buf), count_alloc, NULL,
                                count_free, &err);
            if (img) {
                CHECK_EQ(img->width, 16, "a corrupted GIF never yields a wrong size");
                CHECK_EQ(img->height, 16, "a corrupted GIF never yields a wrong size");
                release_image(img);
            }
        }
    }

    CHECK_EQ(live_blocks, 0, "no failed decode leaks a block");
}

int main(void)
{
    test_plain();
    test_transparent();
    test_interlaced();
    test_animated();
    test_provider();
    test_malformed();

    printf("test_gif: %d checks, %d failures\n", checks, failures);
    printf("%s\n", failures == 0 ? "PASS" : "FAIL");
    return failures == 0 ? 0 : 1;
}
